$ Spice netlist generated by v2lvs
$ v2021.2_37.20    Tue Jun 1 14:42:15 PDT 2021
*.BUSDELIMITER [

.SUBCKT bridge_soc_top clock reset Bridge_Serial_out Serial_in Bridge_Can_out
+ Can_rx R_byte T_byte
*.CONNECT soc_can_rx_inst_next_state[2] VSS
*.CONNECT soc_Can_out VDD
*.CONNECT soc_Serial_out VDD
XDIODE_2 ANTENNA $PINS A=tbyte_PAD VSS=VSS VDD=VDD
XDIODE_1 ANTENNA $PINS A=tbyte_PAD VSS=VSS VDD=VDD
XFE_DBTC0_n_329 INVX8 $PINS Z=FE_DBTN0_n_329 A=n_329 VSS=VSS VDD=VDD
Xcorner0 pad_corner $PINS VSS=VSS VDD=VDD
Xcorner1 pad_corner $PINS VSS=VSS VDD=VDD
Xcorner2 pad_corner $PINS VSS=VSS VDD=VDD
Xcorner3 pad_corner $PINS VSS=VSS VDD=VDD
Xvdd0 pad_vdd $PINS VSS=VSS VDD=VDD
Xvss0 pad_gnd $PINS VSS=VSS VDD=VDD
Xcan_rx_pad pad_in $PINS DataIn=can_rx_PAD pad=Can_rx VSS=VSS VDD=VDD
Xcan_tx_pad pad_out $PINS pad=Bridge_Can_out DataOut=can_tx_PAD VSS=VSS VDD=VDD
Xclk_pad pad_in $PINS DataIn=clk_PAD pad=clock VSS=VSS VDD=VDD
Xrbyte_pad pad_in $PINS DataIn=rbyte_PAD pad=R_byte VSS=VSS VDD=VDD
Xrst_pad pad_in $PINS DataIn=rst_PAD pad=reset VSS=VSS VDD=VDD
Xser_rx_pad pad_in $PINS DataIn=ser_rx_PAD pad=Serial_in VSS=VSS VDD=VDD
Xser_tx_pad pad_out $PINS pad=Bridge_Serial_out DataOut=ser_tx_PAD VSS=VSS
+ VDD=VDD
Xtbyte_pad pad_in $PINS DataIn=tbyte_PAD pad=T_byte VSS=VSS VDD=VDD
Xg4310__2398 NAND3X1 $PINS Z=VDD A=n_822 B=n_830 C=n_828 VSS=VSS VDD=VDD
Xg4311__5107 NAND3X1 $PINS Z=VDD A=n_821 B=n_831 C=n_829 VSS=VSS VDD=VDD
Xg4312__6260 NOR2X1 $PINS Z=n_822 A=soc_uart_tx_inst_shift_reg[0] B=n_21
+ VSS=VSS VDD=VDD
Xg4313__4319 NOR2X1 $PINS Z=n_821 A=soc_can_tx_inst_shift_reg[0] B=n_819
+ VSS=VSS VDD=VDD
Xg4314 INVX2 $PINS Z=soc_uart_tx_inst_n_126 A=n_21 VSS=VSS VDD=VDD
Xg4315__8428 NOR2X1 $PINS Z=n_819 A=soc_can_tx_inst_state[0]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg4316__5526 NOR2X1 $PINS Z=n_21 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_state[1] VSS=VSS VDD=VDD
Xg4317__6783 OR2X1 $PINS Z=n_829 A=soc_Can_ID_Bus[0] B=soc_can_tx_inst_state[1]
+ VSS=VSS VDD=VDD
Xg4318__3680 NAND2X1 $PINS Z=n_830 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_state[0] VSS=VSS VDD=VDD
Xg4319__1617 NAND2X1 $PINS Z=n_831 A=soc_can_tx_inst_state[1]
+ B=soc_can_tx_inst_state[0] VSS=VSS VDD=VDD
Xg4320__2802 OR2X1 $PINS Z=n_828 A=tbyte_PAD B=soc_uart_tx_inst_state[1]
+ VSS=VSS VDD=VDD
Xg4582__5122 NAND3X1 $PINS Z=VSS A=VDD B=n_794 C=n_789 VSS=VSS VDD=VDD
Xg4603__8246 NAND2X1 $PINS Z=soc_can_rx_inst_n_1161 A=n_793
+ B=soc_can_rx_inst_bit_count[4] VSS=VSS VDD=VDD
Xg4605__7098 OR2X1 $PINS Z=n_794 A=rbyte_PAD B=soc_can_rx_inst_n_1142 VSS=VSS
+ VDD=VDD
Xg4607 INVX2 $PINS Z=soc_can_rx_inst_n_1158 A=n_793 VSS=VSS VDD=VDD
Xg4609__5115 NAND2X1 $PINS Z=soc_can_rx_inst_n_1143 A=n_787 B=n_788 VSS=VSS
+ VDD=VDD
Xg4610__7482 NOR2X1 $PINS Z=n_793 A=n_845 B=n_788 VSS=VSS VDD=VDD
Xsoc_Bridge_Can_out_reg DFFQSRX1 $PINS Q=can_tx_PAD CLK=clock D=VDD RESETB=n_19
+ SETB=VDD VSS=VSS VDD=VDD
Xsoc_Bridge_Serial_out_reg DFFQSRX1 $PINS Q=ser_tx_PAD CLK=clock D=VDD
+ RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xg4615__4733 NAND2X1 $PINS Z=n_789 A=soc_can_rx_inst_state[2] B=n_32 VSS=VSS
+ VDD=VDD
Xg4618__6161 NAND2X1 $PINS Z=n_788 A=soc_can_rx_inst_bit_count[3]
+ B=soc_can_rx_inst_bit_count[2] VSS=VSS VDD=VDD
Xg4619__9315 NOR2X1 $PINS Z=n_787 A=soc_can_rx_inst_bit_count[5]
+ B=soc_can_rx_inst_bit_count[4] VSS=VSS VDD=VDD
Xg4624 INVX2 $PINS Z=n_19 A=rst_PAD VSS=VSS VDD=VDD
Xg4628 INVX2 $PINS Z=n_32 A=soc_can_rx_inst_state[1] VSS=VSS VDD=VDD
Xsoc_Can_ID_Bus_reg[0] DFFQSRX1 $PINS Q=soc_Can_ID_Bus[0] CLK=clock D=n_572
+ RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_Load_XMT_datareg_reg DFFQSRX1 $PINS Q=soc_Load_XMT_datareg CLK=clock
+ D=soc_can_data_ready RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_Load_frame_datareg_reg DFFQSRX1 $PINS Q=soc_Load_frame_datareg CLK=clock
+ D=n_429 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_index_reg[0] DFFQSRX1 $PINS Q=soc_can_index[0] CLK=clock D=n_187
+ RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_index_reg[1] DFFQSRX1 $PINS Q=soc_can_index[1] CLK=clock D=n_356
+ RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_index_reg[2] DFFQSRX1 $PINS Q=soc_can_index[2] CLK=clock D=n_379
+ RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_data_ready_reg DFFQSRX1 $PINS Q=soc_can_data_ready
+ CLK=clock D=n_331 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[0] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[0]
+ CLK=clock D=n_765 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[1] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[1]
+ CLK=clock D=n_767 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[2] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[2]
+ CLK=clock D=n_766 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[3] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[3]
+ CLK=clock D=n_764 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[4] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[4]
+ CLK=clock D=n_762 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[5] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[5]
+ CLK=clock D=n_763 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[6] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[6]
+ CLK=clock D=n_772 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_Can_rx_data_Bus_reg[7] DFFQSRX1 $PINS Q=soc_Can_rx_data_Bus[7]
+ CLK=clock D=n_773 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[0] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[0]
+ CLK=clock D=n_649 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[1] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[1]
+ CLK=clock D=n_687 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[2] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[2]
+ CLK=clock D=n_651 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[3] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[3]
+ CLK=clock D=n_652 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[4] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[4]
+ CLK=clock D=n_654 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[5] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[5]
+ CLK=clock D=n_655 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_bit_count_reg[6] DFFQSRX1 $PINS Q=soc_can_rx_inst_bit_count[6]
+ CLK=clock D=n_746 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[60] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[60] CLK=clock D=n_607 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[61] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[61] CLK=clock D=n_604 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[62] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[62] CLK=clock D=n_601 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[63] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[63] CLK=clock D=n_599 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[64] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[64] CLK=clock D=n_596 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[65] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[65] CLK=clock D=n_594 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[66] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[66] CLK=clock D=n_591 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[67] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[67] CLK=clock D=n_590 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[68] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[68] CLK=clock D=n_589 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[69] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[69] CLK=clock D=n_588 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[70] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[70] CLK=clock D=n_587 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[71] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[71] CLK=clock D=n_586 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[72] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[72] CLK=clock D=n_585 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[73] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[73] CLK=clock D=n_584 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[74] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[74] CLK=clock D=n_583 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[75] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[75] CLK=clock D=n_582 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[76] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[76] CLK=clock D=n_581 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[77] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[77] CLK=clock D=n_580 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[78] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[78] CLK=clock D=n_626 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[79] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[79] CLK=clock D=n_625 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[80] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[80] CLK=clock D=n_624 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[81] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[81] CLK=clock D=n_623 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[82] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[82] CLK=clock D=n_621 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[83] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[83] CLK=clock D=n_622 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[84] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[84] CLK=clock D=n_620 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[85] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[85] CLK=clock D=n_619 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[86] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[86] CLK=clock D=n_618 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[87] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[87] CLK=clock D=n_617 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[88] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[88] CLK=clock D=n_616 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[89] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[89] CLK=clock D=n_615 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[90] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[90] CLK=clock D=n_614 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[91] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[91] CLK=clock D=n_613 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[92] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[92] CLK=clock D=n_612 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[93] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[93] CLK=clock D=n_611 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[94] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[94] CLK=clock D=n_610 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[95] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[95] CLK=clock D=n_609 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[96] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[96] CLK=clock D=n_608 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[97] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[97] CLK=clock D=n_606 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[98] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[98] CLK=clock D=n_605 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[99] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[99] CLK=clock D=n_603 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[100] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[100] CLK=clock D=n_602 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[101] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[101] CLK=clock D=n_600 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[102] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[102] CLK=clock D=n_598 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[103] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[103] CLK=clock D=n_597 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[104] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[104] CLK=clock D=n_595 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[105] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[105] CLK=clock D=n_593 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_shift_reg_reg[106] DFFQSRX1 $PINS
+ Q=soc_can_rx_inst_shift_reg[106] CLK=clock D=n_592 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_rx_inst_state_reg[1] DFFQSRX1 $PINS Q=soc_can_rx_inst_state[1]
+ CLK=clock D=VSS RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_rx_inst_state_reg[2] DFFQSRX1 $PINS Q=soc_can_rx_inst_state[2]
+ CLK=clock D=VSS RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[0] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[0] CLK=clock
+ D=n_139 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[1] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[1] CLK=clock
+ D=n_164 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[2] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[2] CLK=clock
+ D=n_177 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[3] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[3] CLK=clock
+ D=n_148 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[4] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[4] CLK=clock
+ D=n_133 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[5] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[5] CLK=clock
+ D=n_145 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[6] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[6] CLK=clock
+ D=n_185 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[7] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[7] CLK=clock
+ D=n_136 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[8] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[8] CLK=clock
+ D=n_134 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[9] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[9] CLK=clock
+ D=n_132 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[10] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[10] CLK=clock
+ D=n_130 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[11] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[11] CLK=clock
+ D=n_129 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[12] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[12] CLK=clock
+ D=n_128 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[13] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[13] CLK=clock
+ D=n_127 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[14] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[14] CLK=clock
+ D=n_126 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[15] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[15] CLK=clock
+ D=n_125 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[16] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[16] CLK=clock
+ D=n_124 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[17] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[17] CLK=clock
+ D=n_123 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[18] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[18] CLK=clock
+ D=n_135 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[19] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[19] CLK=clock
+ D=n_137 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[20] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[20] CLK=clock
+ D=n_186 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[21] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[21] CLK=clock
+ D=n_184 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[22] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[22] CLK=clock
+ D=n_183 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[23] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[23] CLK=clock
+ D=n_182 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[24] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[24] CLK=clock
+ D=n_180 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[25] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[25] CLK=clock
+ D=n_179 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[26] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[26] CLK=clock
+ D=n_178 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[27] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[27] CLK=clock
+ D=n_176 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[28] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[28] CLK=clock
+ D=n_161 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[29] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[29] CLK=clock
+ D=n_174 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[30] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[30] CLK=clock
+ D=n_172 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[31] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[31] CLK=clock
+ D=n_171 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[32] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[32] CLK=clock
+ D=n_181 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[33] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[33] CLK=clock
+ D=n_169 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[34] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[34] CLK=clock
+ D=n_168 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[35] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[35] CLK=clock
+ D=n_167 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[36] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[36] CLK=clock
+ D=n_163 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[37] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[37] CLK=clock
+ D=n_166 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[38] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[38] CLK=clock
+ D=n_175 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[39] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[39] CLK=clock
+ D=n_143 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[40] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[40] CLK=clock
+ D=n_216 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[41] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[41] CLK=clock
+ D=n_142 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[42] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[42] CLK=clock
+ D=n_160 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[43] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[43] CLK=clock
+ D=n_159 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[44] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[44] CLK=clock
+ D=n_173 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[45] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[45] CLK=clock
+ D=n_157 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[46] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[46] CLK=clock
+ D=n_144 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[47] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[47] CLK=clock
+ D=n_156 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[48] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[48] CLK=clock
+ D=n_141 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[49] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[49] CLK=clock
+ D=n_155 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[50] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[50] CLK=clock
+ D=n_153 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[51] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[51] CLK=clock
+ D=n_152 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[52] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[52] CLK=clock
+ D=n_140 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[53] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[53] CLK=clock
+ D=n_151 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[54] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[54] CLK=clock
+ D=n_149 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[55] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[55] CLK=clock
+ D=n_131 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[56] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[56] CLK=clock
+ D=n_138 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[57] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[57] CLK=clock
+ D=n_146 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[58] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[58] CLK=clock
+ D=n_150 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[59] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[59] CLK=clock
+ D=n_154 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[60] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[60] CLK=clock
+ D=n_158 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[61] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[61] CLK=clock
+ D=n_165 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[62] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[62] CLK=clock
+ D=n_170 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_data_bus_reg[63] DFFQSRX1 $PINS Q=soc_can_tx_data_bus[63] CLK=clock
+ D=n_147 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[0] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[0]
+ CLK=clock D=n_643 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[1] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[1]
+ CLK=clock D=n_675 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[2] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[2]
+ CLK=clock D=n_642 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[3] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[3]
+ CLK=clock D=n_677 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[4] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[4]
+ CLK=clock D=n_679 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[5] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[5]
+ CLK=clock D=n_641 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[6] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[6]
+ CLK=clock D=n_640 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[7] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[7]
+ CLK=clock D=n_639 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[8] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[8]
+ CLK=clock D=n_638 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[9] DFFQSRX1 $PINS Q=soc_can_tx_inst_shift_reg[9]
+ CLK=clock D=n_637 RESETB=n_19 SETB=VDD VSS=VSS VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[10] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[10] CLK=clock D=n_380 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[11] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[11] CLK=clock D=n_680 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[12] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[12] CLK=clock D=n_681 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[13] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[13] CLK=clock D=n_682 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[14] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[14] CLK=clock D=n_683 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[15] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[15] CLK=clock D=n_684 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[16] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[16] CLK=clock D=n_685 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[17] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[17] CLK=clock D=n_646 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[18] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[18] CLK=clock D=n_648 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[19] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[19] CLK=clock D=n_647 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[20] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[20] CLK=clock D=n_699 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[21] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[21] CLK=clock D=n_698 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[22] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[22] CLK=clock D=n_697 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[23] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[23] CLK=clock D=n_696 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[24] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[24] CLK=clock D=n_695 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[25] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[25] CLK=clock D=n_694 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[26] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[26] CLK=clock D=n_693 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[27] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[27] CLK=clock D=n_692 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[28] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[28] CLK=clock D=n_691 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[29] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[29] CLK=clock D=n_690 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[30] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[30] CLK=clock D=n_689 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[31] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[31] CLK=clock D=n_717 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[32] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[32] CLK=clock D=n_747 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[33] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[33] CLK=clock D=n_748 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[34] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[34] CLK=clock D=n_749 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[35] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[35] CLK=clock D=n_750 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[36] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[36] CLK=clock D=n_751 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[37] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[37] CLK=clock D=n_752 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[38] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[38] CLK=clock D=n_753 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[39] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[39] CLK=clock D=n_754 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[40] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[40] CLK=clock D=n_755 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[41] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[41] CLK=clock D=n_756 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[42] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[42] CLK=clock D=n_757 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[43] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[43] CLK=clock D=n_758 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[44] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[44] CLK=clock D=n_759 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[45] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[45] CLK=clock D=n_738 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[46] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[46] CLK=clock D=n_737 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[47] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[47] CLK=clock D=n_736 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[48] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[48] CLK=clock D=n_735 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[49] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[49] CLK=clock D=n_734 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[50] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[50] CLK=clock D=n_733 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[51] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[51] CLK=clock D=n_732 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[52] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[52] CLK=clock D=n_731 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[53] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[53] CLK=clock D=n_730 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[54] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[54] CLK=clock D=n_729 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[55] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[55] CLK=clock D=n_728 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[56] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[56] CLK=clock D=n_727 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[57] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[57] CLK=clock D=n_726 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[58] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[58] CLK=clock D=n_725 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[59] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[59] CLK=clock D=n_724 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[60] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[60] CLK=clock D=n_723 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[61] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[61] CLK=clock D=n_722 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[62] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[62] CLK=clock D=n_721 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[63] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[63] CLK=clock D=n_720 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[64] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[64] CLK=clock D=n_719 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[65] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[65] CLK=clock D=n_718 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[66] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[66] CLK=clock D=n_761 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[67] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[67] CLK=clock D=n_716 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[68] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[68] CLK=clock D=n_715 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[69] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[69] CLK=clock D=n_714 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[70] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[70] CLK=clock D=n_713 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[71] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[71] CLK=clock D=n_712 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[72] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[72] CLK=clock D=n_711 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[73] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[73] CLK=clock D=n_710 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[74] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[74] CLK=clock D=n_709 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[75] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[75] CLK=clock D=n_708 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[76] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[76] CLK=clock D=n_707 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[77] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[77] CLK=clock D=n_706 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[78] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[78] CLK=clock D=n_705 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[79] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[79] CLK=clock D=n_704 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[80] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[80] CLK=clock D=n_703 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[81] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[81] CLK=clock D=n_702 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[82] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[82] CLK=clock D=n_701 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[83] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[83] CLK=clock D=n_700 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[84] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[84] CLK=clock D=n_656 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[85] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[85] CLK=clock D=n_657 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[86] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[86] CLK=clock D=n_658 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[87] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[87] CLK=clock D=n_659 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[88] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[88] CLK=clock D=n_660 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[89] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[89] CLK=clock D=n_661 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[90] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[90] CLK=clock D=n_662 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[91] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[91] CLK=clock D=n_663 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[92] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[92] CLK=clock D=n_664 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[93] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[93] CLK=clock D=n_665 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[94] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[94] CLK=clock D=n_666 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[95] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[95] CLK=clock D=n_667 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[96] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[96] CLK=clock D=n_668 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[97] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[97] CLK=clock D=n_669 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[98] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[98] CLK=clock D=n_670 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[99] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[99] CLK=clock D=n_386 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[100] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[100] CLK=clock D=n_671 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[101] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[101] CLK=clock D=n_672 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[102] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[102] CLK=clock D=n_385 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[103] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[103] CLK=clock D=n_384 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[104] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[104] CLK=clock D=n_383 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[105] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[105] CLK=clock D=n_382 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_shift_reg_reg[106] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_shift_reg[106] CLK=clock D=n_435 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_state_reg[0] DFFQSRX1 $PINS Q=soc_can_tx_inst_state[0]
+ CLK=clock D=n_740 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_inst_state_reg[1] DFFQSRX1 $PINS Q=soc_can_tx_inst_state[1]
+ CLK=clock D=n_333 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[0] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[0] CLK=clock D=n_358 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[1] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[1] CLK=clock D=n_854 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[2] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[2] CLK=clock D=n_673 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[3] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[3] CLK=clock D=n_850 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[4] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[4] CLK=clock D=n_774 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[5] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[5] CLK=clock D=n_848 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_can_tx_inst_status_reg_reg[6] DFFQSRX1 $PINS
+ Q=soc_can_tx_inst_status_reg[6] CLK=clock D=n_775 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_bit_count_reg[0] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_bit_count[0] CLK=clock D=n_368 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_bit_count_reg[1] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_bit_count[1] CLK=clock D=n_852 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_bit_count_reg[2] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_bit_count[2] CLK=clock D=n_844 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_bit_count_reg[3] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_bit_count[3] CLK=clock D=n_769 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[1] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[1] CLK=clock D=n_375 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[2] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[2] CLK=clock D=n_374 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[3] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[3] CLK=clock D=n_373 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[4] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[4] CLK=clock D=n_372 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[5] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[5] CLK=clock D=n_376 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[6] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[6] CLK=clock D=n_371 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[7] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[7] CLK=clock D=n_370 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[8] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[8] CLK=clock D=n_377 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_shift_reg_reg[9] DFFQSRX1 $PINS
+ Q=soc_uart_rx_inst_shift_reg[9] CLK=clock D=n_369 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_state_reg[0] DFFQSRX1 $PINS Q=soc_uart_rx_inst_state[0]
+ CLK=clock D=n_430 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_rx_inst_state_reg[1] DFFQSRX1 $PINS Q=soc_uart_rx_inst_state[1]
+ CLK=clock D=n_381 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_rx_inst_uart_data_ready_reg DFFQSRX1 $PINS Q=soc_uart_data_ready
+ CLK=clock D=n_388 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[0] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[0] CLK=clock D=n_634 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[1] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[1] CLK=clock D=n_633 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[2] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[2] CLK=clock D=n_632 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[3] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[3] CLK=clock D=n_631 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[4] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[4] CLK=clock D=n_630 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[5] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[5] CLK=clock D=n_629 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[6] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[6] CLK=clock D=n_628 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_rx_inst_uart_rx_data_bus_reg[7] DFFQSRX1 $PINS
+ Q=soc_uart_rx_data_bus[7] CLK=clock D=n_627 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_data_Bus_reg[0] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[0] CLK=clock
+ D=n_113 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[1] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[1] CLK=clock
+ D=n_117 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[2] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[2] CLK=clock
+ D=n_115 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[3] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[3] CLK=clock
+ D=n_116 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[4] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[4] CLK=clock
+ D=n_112 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[5] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[5] CLK=clock
+ D=n_118 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[6] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[6] CLK=clock
+ D=n_114 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_data_Bus_reg[7] DFFQSRX1 $PINS Q=soc_uart_tx_data_Bus[7] CLK=clock
+ D=n_119 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_inst_Status_reg_reg[0] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_Status_reg[0] CLK=clock D=n_425 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_Status_reg_reg[1] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_Status_reg[1] CLK=clock D=n_686 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_Status_reg_reg[2] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_Status_reg[2] CLK=clock D=n_741 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_Status_reg_reg[3] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_Status_reg[3] CLK=clock D=n_768 RESETB=VDD SETB=n_19 VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[0] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[0] CLK=clock D=n_579 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[1] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[1] CLK=clock D=n_418 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[2] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[2] CLK=clock D=n_407 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[3] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[3] CLK=clock D=n_423 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[4] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[4] CLK=clock D=n_432 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[5] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[5] CLK=clock D=n_467 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[6] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[6] CLK=clock D=n_414 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[7] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[7] CLK=clock D=n_412 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[8] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[8] CLK=clock D=n_484 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_shift_reg_reg[9] DFFQSRX1 $PINS
+ Q=soc_uart_tx_inst_shift_reg[9] CLK=clock D=n_300 RESETB=n_19 SETB=VDD VSS=VSS
+ VDD=VDD
Xsoc_uart_tx_inst_state_reg[0] DFFQSRX1 $PINS Q=soc_uart_tx_inst_state[0]
+ CLK=clock D=n_636 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xsoc_uart_tx_inst_state_reg[1] DFFQSRX1 $PINS Q=soc_uart_tx_inst_state[1]
+ CLK=clock D=n_353 RESETB=VDD SETB=n_19 VSS=VSS VDD=VDD
Xg9905__1666 NAND2X1 $PINS Z=n_775 A=n_770 B=n_570 VSS=VSS VDD=VDD
Xg9952__7410 MUX2X1 $PINS Z=n_774 A=n_365 B=n_650
+ S=soc_can_tx_inst_status_reg[4] VSS=VSS VDD=VDD
Xg9953__6417 MUX2X1 $PINS Z=n_773 A=soc_Can_rx_data_Bus[7]
+ B=soc_can_rx_inst_shift_reg[67] S=n_688 VSS=VSS VDD=VDD
Xg9954__5477 MUX2X1 $PINS Z=n_772 A=soc_Can_rx_data_Bus[6]
+ B=soc_can_rx_inst_shift_reg[66] S=n_688 VSS=VSS VDD=VDD
Xg9956__5107 NAND2X1 $PINS Z=n_770 A=n_739 B=soc_can_tx_inst_status_reg[6]
+ VSS=VSS VDD=VDD
Xg9957__6260 NAND2X1 $PINS Z=n_769 A=n_742 B=n_351 VSS=VSS VDD=VDD
Xg9958__4319 AND2X1 $PINS Z=n_768 A=n_760 B=n_830 VSS=VSS VDD=VDD
Xg9959__8428 MUX2X1 $PINS Z=n_767 A=soc_Can_rx_data_Bus[1]
+ B=soc_can_rx_inst_shift_reg[61] S=n_688 VSS=VSS VDD=VDD
Xg9960__5526 MUX2X1 $PINS Z=n_766 A=soc_Can_rx_data_Bus[2]
+ B=soc_can_rx_inst_shift_reg[62] S=n_688 VSS=VSS VDD=VDD
Xg9961__6783 MUX2X1 $PINS Z=n_765 A=soc_Can_rx_data_Bus[0]
+ B=soc_can_rx_inst_shift_reg[60] S=n_688 VSS=VSS VDD=VDD
Xg9962__3680 MUX2X1 $PINS Z=n_764 A=soc_Can_rx_data_Bus[3]
+ B=soc_can_rx_inst_shift_reg[63] S=n_688 VSS=VSS VDD=VDD
Xg9963__1617 MUX2X1 $PINS Z=n_763 A=soc_Can_rx_data_Bus[5]
+ B=soc_can_rx_inst_shift_reg[65] S=n_688 VSS=VSS VDD=VDD
Xg9964__2802 MUX2X1 $PINS Z=n_762 A=soc_Can_rx_data_Bus[4]
+ B=soc_can_rx_inst_shift_reg[64] S=n_688 VSS=VSS VDD=VDD
Xg10080__1705 NAND3X1 $PINS Z=n_761 A=n_525 B=n_537 C=n_264 VSS=VSS VDD=VDD
Xg10081__5122 MUX2X1 $PINS Z=n_760 A=n_367 B=soc_uart_tx_inst_Status_reg[3]
+ S=n_104 VSS=VSS VDD=VDD
Xg10082__8246 NAND3X1 $PINS Z=n_759 A=n_389 B=n_559 C=n_310 VSS=VSS VDD=VDD
Xg10083__7098 NAND3X1 $PINS Z=n_758 A=n_390 B=n_496 C=n_197 VSS=VSS VDD=VDD
Xg10084__6131 NAND3X1 $PINS Z=n_757 A=n_391 B=n_497 C=n_198 VSS=VSS VDD=VDD
Xg10085__1881 NAND3X1 $PINS Z=n_756 A=n_392 B=n_498 C=n_199 VSS=VSS VDD=VDD
Xg10086__5115 NAND3X1 $PINS Z=n_755 A=n_393 B=n_499 C=n_201 VSS=VSS VDD=VDD
Xg10087__7482 NAND3X1 $PINS Z=n_754 A=n_394 B=n_500 C=n_203 VSS=VSS VDD=VDD
Xg10088__4733 NAND3X1 $PINS Z=n_753 A=n_395 B=n_501 C=n_204 VSS=VSS VDD=VDD
Xg10089__6161 NAND3X1 $PINS Z=n_752 A=n_396 B=n_502 C=n_205 VSS=VSS VDD=VDD
Xg10090__9315 NAND3X1 $PINS Z=n_751 A=n_397 B=n_503 C=n_206 VSS=VSS VDD=VDD
Xg10091__9945 NAND3X1 $PINS Z=n_750 A=n_398 B=n_504 C=n_207 VSS=VSS VDD=VDD
Xg10092__2883 NAND3X1 $PINS Z=n_749 A=n_399 B=n_505 C=n_210 VSS=VSS VDD=VDD
Xg10093__2346 NAND3X1 $PINS Z=n_748 A=n_400 B=n_506 C=n_211 VSS=VSS VDD=VDD
Xg10094__1666 NAND3X1 $PINS Z=n_747 A=n_401 B=n_507 C=n_212 VSS=VSS VDD=VDD
Xg10095__7410 NAND2X1 $PINS Z=n_746 A=n_344 B=n_645 VSS=VSS VDD=VDD
Xg10097__5477 OR2X1 $PINS Z=n_744 A=n_42 B=n_650 VSS=VSS VDD=VDD
Xg10099__5107 NAND2X1 $PINS Z=n_742 A=n_678 B=soc_uart_rx_inst_bit_count[3]
+ VSS=VSS VDD=VDD
Xg10100__6260 AND2X1 $PINS Z=n_741 A=n_635 B=n_830 VSS=VSS VDD=VDD
Xg10101__4319 NAND3X1 $PINS Z=n_740 A=n_17 B=n_644 C=n_86 VSS=VSS VDD=VDD
Xg10102__8428 OR2X1 $PINS Z=n_739 A=n_311 B=n_650 VSS=VSS VDD=VDD
Xg10103__5526 NAND3X1 $PINS Z=n_738 A=n_495 B=n_558 C=n_309 VSS=VSS VDD=VDD
Xg10104__6783 NAND3X1 $PINS Z=n_737 A=n_494 B=n_557 C=n_308 VSS=VSS VDD=VDD
Xg10105__3680 NAND3X1 $PINS Z=n_736 A=n_493 B=n_556 C=n_306 VSS=VSS VDD=VDD
Xg10106__1617 NAND3X1 $PINS Z=n_735 A=n_492 B=n_555 C=n_304 VSS=VSS VDD=VDD
Xg10107__2802 NAND3X1 $PINS Z=n_734 A=n_491 B=n_554 C=n_303 VSS=VSS VDD=VDD
Xg10108__1705 NAND3X1 $PINS Z=n_733 A=n_490 B=n_553 C=n_301 VSS=VSS VDD=VDD
Xg10109__5122 NAND3X1 $PINS Z=n_732 A=n_489 B=n_552 C=n_299 VSS=VSS VDD=VDD
Xg10110__8246 NAND3X1 $PINS Z=n_731 A=n_488 B=n_551 C=n_298 VSS=VSS VDD=VDD
Xg10111__7098 NAND3X1 $PINS Z=n_730 A=n_487 B=n_550 C=n_297 VSS=VSS VDD=VDD
Xg10112__6131 NAND3X1 $PINS Z=n_729 A=n_486 B=n_549 C=n_296 VSS=VSS VDD=VDD
Xg10113__1881 NAND3X1 $PINS Z=n_728 A=n_485 B=n_548 C=n_295 VSS=VSS VDD=VDD
Xg10114__5115 NAND3X1 $PINS Z=n_727 A=n_483 B=n_547 C=n_293 VSS=VSS VDD=VDD
Xg10115__7482 NAND3X1 $PINS Z=n_726 A=n_482 B=n_546 C=n_291 VSS=VSS VDD=VDD
Xg10116__4733 NAND3X1 $PINS Z=n_725 A=n_481 B=n_545 C=n_290 VSS=VSS VDD=VDD
Xg10117__6161 NAND3X1 $PINS Z=n_724 A=n_479 B=n_544 C=n_289 VSS=VSS VDD=VDD
Xg10118__9315 NAND3X1 $PINS Z=n_723 A=n_478 B=n_543 C=n_288 VSS=VSS VDD=VDD
Xg10119__9945 NAND3X1 $PINS Z=n_722 A=n_477 B=n_542 C=n_287 VSS=VSS VDD=VDD
Xg10120__2883 NAND3X1 $PINS Z=n_721 A=n_476 B=n_541 C=n_286 VSS=VSS VDD=VDD
Xg10121__2346 NAND3X1 $PINS Z=n_720 A=n_475 B=n_540 C=n_285 VSS=VSS VDD=VDD
Xg10122__1666 NAND3X1 $PINS Z=n_719 A=n_573 B=n_539 C=n_283 VSS=VSS VDD=VDD
Xg10123__7410 NAND3X1 $PINS Z=n_718 A=n_575 B=n_538 C=n_282 VSS=VSS VDD=VDD
Xg10124__6417 NAND3X1 $PINS Z=n_717 A=n_402 B=n_508 C=n_213 VSS=VSS VDD=VDD
Xg10125__5477 NAND3X1 $PINS Z=n_716 A=n_473 B=n_536 C=n_280 VSS=VSS VDD=VDD
Xg10126__2398 NAND3X1 $PINS Z=n_715 A=n_472 B=n_535 C=n_279 VSS=VSS VDD=VDD
Xg10127__5107 NAND3X1 $PINS Z=n_714 A=n_470 B=n_534 C=n_278 VSS=VSS VDD=VDD
Xg10128__6260 NAND3X1 $PINS Z=n_713 A=n_469 B=n_533 C=n_277 VSS=VSS VDD=VDD
Xg10129__4319 NAND3X1 $PINS Z=n_712 A=n_468 B=n_532 C=n_276 VSS=VSS VDD=VDD
Xg10130__8428 NAND3X1 $PINS Z=n_711 A=n_466 B=n_531 C=n_275 VSS=VSS VDD=VDD
Xg10131__5526 NAND3X1 $PINS Z=n_710 A=n_465 B=n_530 C=n_208 VSS=VSS VDD=VDD
Xg10132__6783 NAND3X1 $PINS Z=n_709 A=n_464 B=n_529 C=n_274 VSS=VSS VDD=VDD
Xg10133__3680 NAND3X1 $PINS Z=n_708 A=n_463 B=n_528 C=n_272 VSS=VSS VDD=VDD
Xg10134__1617 NAND3X1 $PINS Z=n_707 A=n_462 B=n_527 C=n_236 VSS=VSS VDD=VDD
Xg10135__2802 NAND3X1 $PINS Z=n_706 A=n_461 B=n_526 C=n_270 VSS=VSS VDD=VDD
Xg10136__1705 NAND3X1 $PINS Z=n_705 A=n_459 B=n_576 C=n_269 VSS=VSS VDD=VDD
Xg10137__5122 NAND3X1 $PINS Z=n_704 A=n_458 B=n_524 C=n_267 VSS=VSS VDD=VDD
Xg10138__8246 NAND3X1 $PINS Z=n_703 A=n_457 B=n_523 C=n_233 VSS=VSS VDD=VDD
Xg10139__7098 NAND3X1 $PINS Z=n_702 A=n_456 B=n_522 C=n_320 VSS=VSS VDD=VDD
Xg10140__6131 NAND3X1 $PINS Z=n_701 A=n_455 B=n_521 C=n_265 VSS=VSS VDD=VDD
Xg10141__1881 NAND3X1 $PINS Z=n_700 A=n_454 B=n_520 C=n_263 VSS=VSS VDD=VDD
Xg10142__5115 NAND3X1 $PINS Z=n_699 A=n_417 B=n_519 C=n_224 VSS=VSS VDD=VDD
Xg10143__7482 NAND3X1 $PINS Z=n_698 A=n_416 B=n_518 C=n_273 VSS=VSS VDD=VDD
Xg10144__4733 NAND3X1 $PINS Z=n_697 A=n_415 B=n_517 C=n_268 VSS=VSS VDD=VDD
Xg10145__6161 NAND3X1 $PINS Z=n_696 A=n_413 B=n_516 C=n_281 VSS=VSS VDD=VDD
Xg10146__9315 NAND3X1 $PINS Z=n_695 A=n_410 B=n_515 C=n_266 VSS=VSS VDD=VDD
Xg10147__9945 NAND3X1 $PINS Z=n_694 A=n_409 B=n_514 C=n_284 VSS=VSS VDD=VDD
Xg10148__2883 NAND3X1 $PINS Z=n_693 A=n_408 B=n_513 C=n_316 VSS=VSS VDD=VDD
Xg10149__2346 NAND3X1 $PINS Z=n_692 A=n_406 B=n_512 C=n_318 VSS=VSS VDD=VDD
Xg10150__1666 NAND3X1 $PINS Z=n_691 A=n_405 B=n_511 C=n_162 VSS=VSS VDD=VDD
Xg10151__7410 NAND3X1 $PINS Z=n_690 A=n_404 B=n_510 C=n_215 VSS=VSS VDD=VDD
Xg10152__6417 NAND3X1 $PINS Z=n_689 A=n_403 B=n_509 C=n_214 VSS=VSS VDD=VDD
Xg10168__5477 NAND2X1 $PINS Z=n_687 A=n_332 B=n_560 VSS=VSS VDD=VDD
Xg10169__2398 AND2X1 $PINS Z=n_686 A=n_378 B=n_830 VSS=VSS VDD=VDD
Xg10170__5107 NAND2X1 $PINS Z=n_685 A=n_422 B=n_226 VSS=VSS VDD=VDD
Xg10171__6260 NAND2X1 $PINS Z=n_684 A=n_424 B=n_227 VSS=VSS VDD=VDD
Xg10172__4319 NAND2X1 $PINS Z=n_683 A=n_426 B=n_248 VSS=VSS VDD=VDD
Xg10173__8428 NAND2X1 $PINS Z=n_682 A=n_427 B=n_228 VSS=VSS VDD=VDD
Xg10174__5526 NAND2X1 $PINS Z=n_681 A=n_428 B=n_307 VSS=VSS VDD=VDD
Xg10175__6783 NAND2X1 $PINS Z=n_680 A=n_411 B=n_229 VSS=VSS VDD=VDD
Xg10176__3680 OR2X1 $PINS Z=n_679 A=n_120 B=n_474 VSS=VSS VDD=VDD
Xg10177__1617 NAND2X1 $PINS Z=n_678 A=n_577 B=n_98 VSS=VSS VDD=VDD
Xg10178__2802 OR2X1 $PINS Z=n_677 A=n_121 B=n_474 VSS=VSS VDD=VDD
Xg10180__5122 OR2X1 $PINS Z=n_675 A=n_122 B=n_474 VSS=VSS VDD=VDD
Xg10182__7098 NAND2X1 $PINS Z=n_673 A=n_346 B=n_433 VSS=VSS VDD=VDD
Xg10183__6131 NAND2X1 $PINS Z=n_672 A=n_436 B=n_222 VSS=VSS VDD=VDD
Xg10184__1881 NAND2X1 $PINS Z=n_671 A=n_437 B=n_249 VSS=VSS VDD=VDD
Xg10185__5115 NAND2X1 $PINS Z=n_670 A=n_438 B=n_251 VSS=VSS VDD=VDD
Xg10186__7482 NAND2X1 $PINS Z=n_669 A=n_439 B=n_202 VSS=VSS VDD=VDD
Xg10187__4733 NAND2X1 $PINS Z=n_668 A=n_440 B=n_252 VSS=VSS VDD=VDD
Xg10188__6161 NAND2X1 $PINS Z=n_667 A=n_441 B=n_253 VSS=VSS VDD=VDD
Xg10189__9315 NAND2X1 $PINS Z=n_666 A=n_442 B=n_254 VSS=VSS VDD=VDD
Xg10190__9945 NAND2X1 $PINS Z=n_665 A=n_443 B=n_231 VSS=VSS VDD=VDD
Xg10191__2883 NAND2X1 $PINS Z=n_664 A=n_444 B=n_255 VSS=VSS VDD=VDD
Xg10192__2346 NAND2X1 $PINS Z=n_663 A=n_445 B=n_256 VSS=VSS VDD=VDD
Xg10193__1666 NAND2X1 $PINS Z=n_662 A=n_446 B=n_257 VSS=VSS VDD=VDD
Xg10194__7410 NAND2X1 $PINS Z=n_661 A=n_447 B=n_258 VSS=VSS VDD=VDD
Xg10195__6417 NAND2X1 $PINS Z=n_660 A=n_448 B=n_259 VSS=VSS VDD=VDD
Xg10196__5477 NAND2X1 $PINS Z=n_659 A=n_449 B=n_260 VSS=VSS VDD=VDD
Xg10197__2398 NAND2X1 $PINS Z=n_658 A=n_450 B=n_261 VSS=VSS VDD=VDD
Xg10198__5107 NAND2X1 $PINS Z=n_657 A=n_451 B=n_230 VSS=VSS VDD=VDD
Xg10199__6260 NAND2X1 $PINS Z=n_656 A=n_452 B=n_262 VSS=VSS VDD=VDD
Xg10200__4319 NAND2X1 $PINS Z=n_655 A=n_453 B=n_343 VSS=VSS VDD=VDD
Xg10201__8428 NAND2X1 $PINS Z=n_654 A=n_342 B=n_460 VSS=VSS VDD=VDD
Xg10203__6783 NAND2X1 $PINS Z=n_652 A=n_335 B=n_471 VSS=VSS VDD=VDD
Xg10204__3680 NAND2X1 $PINS Z=n_651 A=n_330 B=n_480 VSS=VSS VDD=VDD
Xg10237__1617 NOR2X1 $PINS Z=n_688 A=soc_can_rx_inst_n_1143 B=n_574 VSS=VSS
+ VDD=VDD
Xg10239__2802 MUX2X1 $PINS Z=n_649 A=n_15 B=n_217
+ S=soc_can_rx_inst_bit_count[0] VSS=VSS VDD=VDD
Xg10240__1705 NAND2X1 $PINS Z=n_648 A=n_420 B=n_234 VSS=VSS VDD=VDD
Xg10241__5122 NAND2X1 $PINS Z=n_647 A=n_419 B=n_225 VSS=VSS VDD=VDD
Xg10242__8246 NAND2X1 $PINS Z=n_646 A=n_421 B=n_292 VSS=VSS VDD=VDD
Xg10243__7098 NAND2X1 $PINS Z=n_645 A=n_15 B=n_431 VSS=VSS VDD=VDD
Xg10244__6131 NAND3X1 $PINS Z=n_644 A=n_345 B=n_13
+ C=soc_can_tx_inst_status_reg[6] VSS=VSS VDD=VDD
Xg10245__1881 NAND3X1 $PINS Z=n_643 A=n_567 B=n_831 C=n_38 VSS=VSS VDD=VDD
Xg10246__5115 NAND3X1 $PINS Z=n_642 A=n_566 B=n_831 C=n_50 VSS=VSS VDD=VDD
Xg10247__7482 NAND3X1 $PINS Z=n_641 A=n_565 B=n_831 C=n_56 VSS=VSS VDD=VDD
Xg10248__4733 NAND3X1 $PINS Z=n_640 A=n_564 B=n_831 C=n_49 VSS=VSS VDD=VDD
Xg10249__6161 NAND3X1 $PINS Z=n_639 A=n_563 B=n_831 C=n_36 VSS=VSS VDD=VDD
Xg10250__9315 NAND3X1 $PINS Z=n_638 A=n_562 B=n_831 C=n_46 VSS=VSS VDD=VDD
Xg10251__9945 NAND3X1 $PINS Z=n_637 A=n_561 B=n_831 C=n_35 VSS=VSS VDD=VDD
Xg10252__2883 NAND3X1 $PINS Z=n_636 A=n_90 B=n_87 C=n_354 VSS=VSS VDD=VDD
Xg10253__2346 MUX2X1 $PINS Z=n_635 A=n_355 B=soc_uart_tx_inst_Status_reg[2]
+ S=n_104 VSS=VSS VDD=VDD
Xg10254__1666 MUX2X1 $PINS Z=n_634 A=soc_uart_rx_inst_shift_reg[1]
+ B=soc_uart_rx_data_bus[0] S=n_363 VSS=VSS VDD=VDD
Xg10255__7410 MUX2X1 $PINS Z=n_633 A=soc_uart_rx_inst_shift_reg[2]
+ B=soc_uart_rx_data_bus[1] S=n_363 VSS=VSS VDD=VDD
Xg10256__6417 MUX2X1 $PINS Z=n_632 A=soc_uart_rx_inst_shift_reg[3]
+ B=soc_uart_rx_data_bus[2] S=n_363 VSS=VSS VDD=VDD
Xg10257__5477 MUX2X1 $PINS Z=n_631 A=soc_uart_rx_inst_shift_reg[4]
+ B=soc_uart_rx_data_bus[3] S=n_363 VSS=VSS VDD=VDD
Xg10258__2398 MUX2X1 $PINS Z=n_630 A=soc_uart_rx_inst_shift_reg[5]
+ B=soc_uart_rx_data_bus[4] S=n_363 VSS=VSS VDD=VDD
Xg10259__5107 MUX2X1 $PINS Z=n_629 A=soc_uart_rx_inst_shift_reg[6]
+ B=soc_uart_rx_data_bus[5] S=n_363 VSS=VSS VDD=VDD
Xg10260__6260 MUX2X1 $PINS Z=n_628 A=soc_uart_rx_inst_shift_reg[7]
+ B=soc_uart_rx_data_bus[6] S=n_363 VSS=VSS VDD=VDD
Xg10261__4319 MUX2X1 $PINS Z=n_627 A=soc_uart_rx_inst_shift_reg[8]
+ B=soc_uart_rx_data_bus[7] S=n_363 VSS=VSS VDD=VDD
Xg10262__8428 MUX2X1 $PINS Z=n_626 A=soc_can_rx_inst_shift_reg[78]
+ B=soc_can_rx_inst_shift_reg[79] S=n_15 VSS=VSS VDD=VDD
Xg10263__5526 MUX2X1 $PINS Z=n_625 A=soc_can_rx_inst_shift_reg[79]
+ B=soc_can_rx_inst_shift_reg[80] S=n_15 VSS=VSS VDD=VDD
Xg10264__6783 MUX2X1 $PINS Z=n_624 A=soc_can_rx_inst_shift_reg[80]
+ B=soc_can_rx_inst_shift_reg[81] S=n_15 VSS=VSS VDD=VDD
Xg10265__3680 MUX2X1 $PINS Z=n_623 A=soc_can_rx_inst_shift_reg[81]
+ B=soc_can_rx_inst_shift_reg[82] S=n_15 VSS=VSS VDD=VDD
Xg10266__1617 MUX2X1 $PINS Z=n_622 A=soc_can_rx_inst_shift_reg[83]
+ B=soc_can_rx_inst_shift_reg[84] S=n_15 VSS=VSS VDD=VDD
Xg10267__2802 MUX2X1 $PINS Z=n_621 A=soc_can_rx_inst_shift_reg[82]
+ B=soc_can_rx_inst_shift_reg[83] S=n_15 VSS=VSS VDD=VDD
Xg10268__1705 MUX2X1 $PINS Z=n_620 A=soc_can_rx_inst_shift_reg[84]
+ B=soc_can_rx_inst_shift_reg[85] S=n_15 VSS=VSS VDD=VDD
Xg10269__5122 MUX2X1 $PINS Z=n_619 A=soc_can_rx_inst_shift_reg[85]
+ B=soc_can_rx_inst_shift_reg[86] S=n_15 VSS=VSS VDD=VDD
Xg10270__8246 MUX2X1 $PINS Z=n_618 A=soc_can_rx_inst_shift_reg[86]
+ B=soc_can_rx_inst_shift_reg[87] S=n_15 VSS=VSS VDD=VDD
Xg10271__7098 MUX2X1 $PINS Z=n_617 A=soc_can_rx_inst_shift_reg[87]
+ B=soc_can_rx_inst_shift_reg[88] S=n_15 VSS=VSS VDD=VDD
Xg10272__6131 MUX2X1 $PINS Z=n_616 A=soc_can_rx_inst_shift_reg[88]
+ B=soc_can_rx_inst_shift_reg[89] S=n_15 VSS=VSS VDD=VDD
Xg10273__1881 MUX2X1 $PINS Z=n_615 A=soc_can_rx_inst_shift_reg[89]
+ B=soc_can_rx_inst_shift_reg[90] S=n_15 VSS=VSS VDD=VDD
Xg10274__5115 MUX2X1 $PINS Z=n_614 A=soc_can_rx_inst_shift_reg[90]
+ B=soc_can_rx_inst_shift_reg[91] S=n_15 VSS=VSS VDD=VDD
Xg10275__7482 MUX2X1 $PINS Z=n_613 A=soc_can_rx_inst_shift_reg[91]
+ B=soc_can_rx_inst_shift_reg[92] S=n_15 VSS=VSS VDD=VDD
Xg10276__4733 MUX2X1 $PINS Z=n_612 A=soc_can_rx_inst_shift_reg[92]
+ B=soc_can_rx_inst_shift_reg[93] S=n_15 VSS=VSS VDD=VDD
Xg10277__6161 MUX2X1 $PINS Z=n_611 A=soc_can_rx_inst_shift_reg[93]
+ B=soc_can_rx_inst_shift_reg[94] S=n_15 VSS=VSS VDD=VDD
Xg10278__9315 MUX2X1 $PINS Z=n_610 A=soc_can_rx_inst_shift_reg[94]
+ B=soc_can_rx_inst_shift_reg[95] S=n_15 VSS=VSS VDD=VDD
Xg10279__9945 MUX2X1 $PINS Z=n_609 A=soc_can_rx_inst_shift_reg[95]
+ B=soc_can_rx_inst_shift_reg[96] S=n_15 VSS=VSS VDD=VDD
Xg10280__2883 MUX2X1 $PINS Z=n_608 A=soc_can_rx_inst_shift_reg[96]
+ B=soc_can_rx_inst_shift_reg[97] S=n_15 VSS=VSS VDD=VDD
Xg10281__2346 MUX2X1 $PINS Z=n_607 A=soc_can_rx_inst_shift_reg[60]
+ B=soc_can_rx_inst_shift_reg[61] S=n_15 VSS=VSS VDD=VDD
Xg10282__1666 MUX2X1 $PINS Z=n_606 A=soc_can_rx_inst_shift_reg[97]
+ B=soc_can_rx_inst_shift_reg[98] S=n_15 VSS=VSS VDD=VDD
Xg10283__7410 MUX2X1 $PINS Z=n_605 A=soc_can_rx_inst_shift_reg[98]
+ B=soc_can_rx_inst_shift_reg[99] S=n_15 VSS=VSS VDD=VDD
Xg10284__6417 MUX2X1 $PINS Z=n_604 A=soc_can_rx_inst_shift_reg[61]
+ B=soc_can_rx_inst_shift_reg[62] S=n_15 VSS=VSS VDD=VDD
Xg10285__5477 MUX2X1 $PINS Z=n_603 A=soc_can_rx_inst_shift_reg[99]
+ B=soc_can_rx_inst_shift_reg[100] S=n_15 VSS=VSS VDD=VDD
Xg10286__2398 MUX2X1 $PINS Z=n_602 A=soc_can_rx_inst_shift_reg[100]
+ B=soc_can_rx_inst_shift_reg[101] S=n_15 VSS=VSS VDD=VDD
Xg10287__5107 MUX2X1 $PINS Z=n_601 A=soc_can_rx_inst_shift_reg[62]
+ B=soc_can_rx_inst_shift_reg[63] S=n_15 VSS=VSS VDD=VDD
Xg10288__6260 MUX2X1 $PINS Z=n_600 A=soc_can_rx_inst_shift_reg[101]
+ B=soc_can_rx_inst_shift_reg[102] S=n_15 VSS=VSS VDD=VDD
Xg10289__4319 MUX2X1 $PINS Z=n_599 A=soc_can_rx_inst_shift_reg[63]
+ B=soc_can_rx_inst_shift_reg[64] S=n_15 VSS=VSS VDD=VDD
Xg10290__8428 MUX2X1 $PINS Z=n_598 A=soc_can_rx_inst_shift_reg[102]
+ B=soc_can_rx_inst_shift_reg[103] S=n_15 VSS=VSS VDD=VDD
Xg10291__5526 MUX2X1 $PINS Z=n_597 A=soc_can_rx_inst_shift_reg[103]
+ B=soc_can_rx_inst_shift_reg[104] S=n_15 VSS=VSS VDD=VDD
Xg10292__6783 MUX2X1 $PINS Z=n_596 A=soc_can_rx_inst_shift_reg[64]
+ B=soc_can_rx_inst_shift_reg[65] S=n_15 VSS=VSS VDD=VDD
Xg10293__3680 MUX2X1 $PINS Z=n_595 A=soc_can_rx_inst_shift_reg[104]
+ B=soc_can_rx_inst_shift_reg[105] S=n_15 VSS=VSS VDD=VDD
Xg10294__1617 MUX2X1 $PINS Z=n_594 A=soc_can_rx_inst_shift_reg[65]
+ B=soc_can_rx_inst_shift_reg[66] S=n_15 VSS=VSS VDD=VDD
Xg10295__2802 MUX2X1 $PINS Z=n_593 A=soc_can_rx_inst_shift_reg[105]
+ B=soc_can_rx_inst_shift_reg[106] S=n_15 VSS=VSS VDD=VDD
Xg10296__1705 MUX2X1 $PINS Z=n_592 A=soc_can_rx_inst_shift_reg[106]
+ B=can_rx_PAD S=n_15 VSS=VSS VDD=VDD
Xg10297__5122 MUX2X1 $PINS Z=n_591 A=soc_can_rx_inst_shift_reg[66]
+ B=soc_can_rx_inst_shift_reg[67] S=n_15 VSS=VSS VDD=VDD
Xg10298__8246 MUX2X1 $PINS Z=n_590 A=soc_can_rx_inst_shift_reg[67]
+ B=soc_can_rx_inst_shift_reg[68] S=n_15 VSS=VSS VDD=VDD
Xg10299__7098 MUX2X1 $PINS Z=n_589 A=soc_can_rx_inst_shift_reg[68]
+ B=soc_can_rx_inst_shift_reg[69] S=n_15 VSS=VSS VDD=VDD
Xg10300__6131 MUX2X1 $PINS Z=n_588 A=soc_can_rx_inst_shift_reg[69]
+ B=soc_can_rx_inst_shift_reg[70] S=n_15 VSS=VSS VDD=VDD
Xg10301__1881 MUX2X1 $PINS Z=n_587 A=soc_can_rx_inst_shift_reg[70]
+ B=soc_can_rx_inst_shift_reg[71] S=n_15 VSS=VSS VDD=VDD
Xg10302__5115 MUX2X1 $PINS Z=n_586 A=soc_can_rx_inst_shift_reg[71]
+ B=soc_can_rx_inst_shift_reg[72] S=n_15 VSS=VSS VDD=VDD
Xg10303__7482 MUX2X1 $PINS Z=n_585 A=soc_can_rx_inst_shift_reg[72]
+ B=soc_can_rx_inst_shift_reg[73] S=n_15 VSS=VSS VDD=VDD
Xg10304__4733 MUX2X1 $PINS Z=n_584 A=soc_can_rx_inst_shift_reg[73]
+ B=soc_can_rx_inst_shift_reg[74] S=n_15 VSS=VSS VDD=VDD
Xg10305__6161 MUX2X1 $PINS Z=n_583 A=soc_can_rx_inst_shift_reg[74]
+ B=soc_can_rx_inst_shift_reg[75] S=n_15 VSS=VSS VDD=VDD
Xg10306__9315 MUX2X1 $PINS Z=n_582 A=soc_can_rx_inst_shift_reg[75]
+ B=soc_can_rx_inst_shift_reg[76] S=n_15 VSS=VSS VDD=VDD
Xg10307__9945 MUX2X1 $PINS Z=n_581 A=soc_can_rx_inst_shift_reg[76]
+ B=soc_can_rx_inst_shift_reg[77] S=n_15 VSS=VSS VDD=VDD
Xg10308__2883 MUX2X1 $PINS Z=n_580 A=soc_can_rx_inst_shift_reg[77]
+ B=soc_can_rx_inst_shift_reg[78] S=n_15 VSS=VSS VDD=VDD
Xg10309__2346 MUX2X1 $PINS Z=n_579 A=n_357 B=soc_uart_tx_inst_n_126 S=n_67
+ VSS=VSS VDD=VDD
Xg10310__1666 NAND2X1 $PINS Z=n_650 A=n_568 B=soc_can_tx_inst_state[1] VSS=VSS
+ VDD=VDD
Xg10312__7410 NAND2X1 $PINS Z=n_576 A=n_16 B=soc_can_tx_data_bus[58] VSS=VSS
+ VDD=VDD
Xg10313__6417 NAND2X1 $PINS Z=n_575 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[65] VSS=VSS VDD=VDD
Xg10314__5477 OR2X1 $PINS Z=n_574 A=soc_can_rx_inst_n_1142 B=n_341 VSS=VSS
+ VDD=VDD
Xg10315__2398 NAND2X1 $PINS Z=n_573 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[64] VSS=VSS VDD=VDD
Xg10316__5107 OR2X1 $PINS Z=n_572 A=soc_Can_ID_Bus[0] B=n_366 VSS=VSS VDD=VDD
Xg10318__4319 NAND2X1 $PINS Z=n_570 A=n_365 B=n_235 VSS=VSS VDD=VDD
Xg10320__5526 NAND2X1 $PINS Z=n_568 A=n_340 B=n_7 VSS=VSS VDD=VDD
Xg10321__6783 NAND2X1 $PINS Z=n_567 A=n_364 B=soc_can_tx_inst_shift_reg[0]
+ VSS=VSS VDD=VDD
Xg10322__3680 NAND2X1 $PINS Z=n_566 A=n_364 B=soc_can_tx_inst_shift_reg[2]
+ VSS=VSS VDD=VDD
Xg10323__1617 NAND2X1 $PINS Z=n_565 A=n_364 B=soc_can_tx_inst_shift_reg[5]
+ VSS=VSS VDD=VDD
Xg10324__2802 NAND2X1 $PINS Z=n_564 A=n_364 B=soc_can_tx_inst_shift_reg[6]
+ VSS=VSS VDD=VDD
Xg10325__1705 NAND2X1 $PINS Z=n_563 A=n_364 B=soc_can_tx_inst_shift_reg[7]
+ VSS=VSS VDD=VDD
Xg10326__5122 NAND2X1 $PINS Z=n_562 A=n_364 B=soc_can_tx_inst_shift_reg[8]
+ VSS=VSS VDD=VDD
Xg10327__8246 NAND2X1 $PINS Z=n_561 A=n_364 B=soc_can_tx_inst_shift_reg[9]
+ VSS=VSS VDD=VDD
Xg10328__7098 NAND2X1 $PINS Z=n_560 A=n_15 B=n_200 VSS=VSS VDD=VDD
Xg10329__6131 NAND2X1 $PINS Z=n_559 A=n_16 B=soc_can_tx_data_bus[24] VSS=VSS
+ VDD=VDD
Xg10330__1881 NAND2X1 $PINS Z=n_558 A=n_16 B=soc_can_tx_data_bus[25] VSS=VSS
+ VDD=VDD
Xg10331__5115 NAND2X1 $PINS Z=n_557 A=n_16 B=soc_can_tx_data_bus[26] VSS=VSS
+ VDD=VDD
Xg10332__7482 NAND2X1 $PINS Z=n_556 A=n_16 B=soc_can_tx_data_bus[27] VSS=VSS
+ VDD=VDD
Xg10333__4733 NAND2X1 $PINS Z=n_555 A=n_16 B=soc_can_tx_data_bus[28] VSS=VSS
+ VDD=VDD
Xg10334__6161 NAND2X1 $PINS Z=n_554 A=n_16 B=soc_can_tx_data_bus[29] VSS=VSS
+ VDD=VDD
Xg10335__9315 NAND2X1 $PINS Z=n_553 A=n_16 B=soc_can_tx_data_bus[30] VSS=VSS
+ VDD=VDD
Xg10336__9945 NAND2X1 $PINS Z=n_552 A=n_16 B=soc_can_tx_data_bus[31] VSS=VSS
+ VDD=VDD
Xg10337__2883 NAND2X1 $PINS Z=n_551 A=n_16 B=soc_can_tx_data_bus[32] VSS=VSS
+ VDD=VDD
Xg10338__2346 NAND2X1 $PINS Z=n_550 A=n_16 B=soc_can_tx_data_bus[33] VSS=VSS
+ VDD=VDD
Xg10339__1666 NAND2X1 $PINS Z=n_549 A=n_16 B=soc_can_tx_data_bus[34] VSS=VSS
+ VDD=VDD
Xg10340__7410 NAND2X1 $PINS Z=n_548 A=n_16 B=soc_can_tx_data_bus[35] VSS=VSS
+ VDD=VDD
Xg10341__6417 NAND2X1 $PINS Z=n_547 A=n_16 B=soc_can_tx_data_bus[36] VSS=VSS
+ VDD=VDD
Xg10342__5477 NAND2X1 $PINS Z=n_546 A=n_16 B=soc_can_tx_data_bus[37] VSS=VSS
+ VDD=VDD
Xg10343__2398 NAND2X1 $PINS Z=n_545 A=n_16 B=soc_can_tx_data_bus[38] VSS=VSS
+ VDD=VDD
Xg10344__5107 NAND2X1 $PINS Z=n_544 A=n_16 B=soc_can_tx_data_bus[39] VSS=VSS
+ VDD=VDD
Xg10345__6260 NAND2X1 $PINS Z=n_543 A=n_16 B=soc_can_tx_data_bus[40] VSS=VSS
+ VDD=VDD
Xg10346__4319 NAND2X1 $PINS Z=n_542 A=n_16 B=soc_can_tx_data_bus[41] VSS=VSS
+ VDD=VDD
Xg10347__8428 NAND2X1 $PINS Z=n_541 A=n_16 B=soc_can_tx_data_bus[42] VSS=VSS
+ VDD=VDD
Xg10348__5526 NAND2X1 $PINS Z=n_540 A=n_16 B=soc_can_tx_data_bus[43] VSS=VSS
+ VDD=VDD
Xg10349__6783 NAND2X1 $PINS Z=n_539 A=n_16 B=soc_can_tx_data_bus[44] VSS=VSS
+ VDD=VDD
Xg10350__3680 NAND2X1 $PINS Z=n_538 A=n_16 B=soc_can_tx_data_bus[45] VSS=VSS
+ VDD=VDD
Xg10351__1617 NAND2X1 $PINS Z=n_537 A=n_16 B=soc_can_tx_data_bus[46] VSS=VSS
+ VDD=VDD
Xg10352__2802 NAND2X1 $PINS Z=n_536 A=n_16 B=soc_can_tx_data_bus[47] VSS=VSS
+ VDD=VDD
Xg10353__1705 NAND2X1 $PINS Z=n_535 A=n_16 B=soc_can_tx_data_bus[48] VSS=VSS
+ VDD=VDD
Xg10354__5122 NAND2X1 $PINS Z=n_534 A=n_16 B=soc_can_tx_data_bus[49] VSS=VSS
+ VDD=VDD
Xg10355__8246 NAND2X1 $PINS Z=n_533 A=n_16 B=soc_can_tx_data_bus[50] VSS=VSS
+ VDD=VDD
Xg10356__7098 NAND2X1 $PINS Z=n_532 A=n_16 B=soc_can_tx_data_bus[51] VSS=VSS
+ VDD=VDD
Xg10357__6131 NAND2X1 $PINS Z=n_531 A=n_16 B=soc_can_tx_data_bus[52] VSS=VSS
+ VDD=VDD
Xg10358__1881 NAND2X1 $PINS Z=n_530 A=n_16 B=soc_can_tx_data_bus[53] VSS=VSS
+ VDD=VDD
Xg10359__5115 NAND2X1 $PINS Z=n_529 A=n_16 B=soc_can_tx_data_bus[54] VSS=VSS
+ VDD=VDD
Xg10360__7482 NAND2X1 $PINS Z=n_528 A=n_16 B=soc_can_tx_data_bus[55] VSS=VSS
+ VDD=VDD
Xg10361__4733 NAND2X1 $PINS Z=n_527 A=n_16 B=soc_can_tx_data_bus[56] VSS=VSS
+ VDD=VDD
Xg10362__6161 NAND2X1 $PINS Z=n_526 A=n_16 B=soc_can_tx_data_bus[57] VSS=VSS
+ VDD=VDD
Xg10363__9315 NAND2X1 $PINS Z=n_525 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[66] VSS=VSS VDD=VDD
Xg10364__9945 NAND2X1 $PINS Z=n_524 A=n_16 B=soc_can_tx_data_bus[59] VSS=VSS
+ VDD=VDD
Xg10365__2883 NAND2X1 $PINS Z=n_523 A=n_16 B=soc_can_tx_data_bus[60] VSS=VSS
+ VDD=VDD
Xg10366__2346 NAND2X1 $PINS Z=n_522 A=n_16 B=soc_can_tx_data_bus[61] VSS=VSS
+ VDD=VDD
Xg10367__1666 NAND2X1 $PINS Z=n_521 A=n_16 B=soc_can_tx_data_bus[62] VSS=VSS
+ VDD=VDD
Xg10368__7410 NAND2X1 $PINS Z=n_520 A=n_16 B=soc_can_tx_data_bus[63] VSS=VSS
+ VDD=VDD
Xg10369__6417 NAND2X1 $PINS Z=n_519 A=n_16 B=soc_can_tx_data_bus[0] VSS=VSS
+ VDD=VDD
Xg10370__5477 NAND2X1 $PINS Z=n_518 A=n_16 B=soc_can_tx_data_bus[1] VSS=VSS
+ VDD=VDD
Xg10371__2398 NAND2X1 $PINS Z=n_517 A=n_16 B=soc_can_tx_data_bus[2] VSS=VSS
+ VDD=VDD
Xg10372__5107 NAND2X1 $PINS Z=n_516 A=n_16 B=soc_can_tx_data_bus[3] VSS=VSS
+ VDD=VDD
Xg10373__6260 NAND2X1 $PINS Z=n_515 A=n_16 B=soc_can_tx_data_bus[4] VSS=VSS
+ VDD=VDD
Xg10374__4319 NAND2X1 $PINS Z=n_514 A=n_16 B=soc_can_tx_data_bus[5] VSS=VSS
+ VDD=VDD
Xg10375__8428 NAND2X1 $PINS Z=n_513 A=n_16 B=soc_can_tx_data_bus[6] VSS=VSS
+ VDD=VDD
Xg10376__5526 NAND2X1 $PINS Z=n_512 A=n_16 B=soc_can_tx_data_bus[7] VSS=VSS
+ VDD=VDD
Xg10377__6783 NAND2X1 $PINS Z=n_511 A=n_16 B=soc_can_tx_data_bus[8] VSS=VSS
+ VDD=VDD
Xg10378__3680 NAND2X1 $PINS Z=n_510 A=n_16 B=soc_can_tx_data_bus[9] VSS=VSS
+ VDD=VDD
Xg10379__1617 NAND2X1 $PINS Z=n_509 A=n_16 B=soc_can_tx_data_bus[10] VSS=VSS
+ VDD=VDD
Xg10380__2802 NAND2X1 $PINS Z=n_508 A=n_16 B=soc_can_tx_data_bus[11] VSS=VSS
+ VDD=VDD
Xg10381__1705 NAND2X1 $PINS Z=n_507 A=n_16 B=soc_can_tx_data_bus[12] VSS=VSS
+ VDD=VDD
Xg10382__5122 NAND2X1 $PINS Z=n_506 A=n_16 B=soc_can_tx_data_bus[13] VSS=VSS
+ VDD=VDD
Xg10383__8246 NAND2X1 $PINS Z=n_505 A=n_16 B=soc_can_tx_data_bus[14] VSS=VSS
+ VDD=VDD
Xg10384__7098 NAND2X1 $PINS Z=n_504 A=n_16 B=soc_can_tx_data_bus[15] VSS=VSS
+ VDD=VDD
Xg10385__6131 NAND2X1 $PINS Z=n_503 A=n_16 B=soc_can_tx_data_bus[16] VSS=VSS
+ VDD=VDD
Xg10386__1881 NAND2X1 $PINS Z=n_502 A=n_16 B=soc_can_tx_data_bus[17] VSS=VSS
+ VDD=VDD
Xg10387__5115 NAND2X1 $PINS Z=n_501 A=n_16 B=soc_can_tx_data_bus[18] VSS=VSS
+ VDD=VDD
Xg10388__7482 NAND2X1 $PINS Z=n_500 A=n_16 B=soc_can_tx_data_bus[19] VSS=VSS
+ VDD=VDD
Xg10389__4733 NAND2X1 $PINS Z=n_499 A=n_16 B=soc_can_tx_data_bus[20] VSS=VSS
+ VDD=VDD
Xg10390__6161 NAND2X1 $PINS Z=n_498 A=n_16 B=soc_can_tx_data_bus[21] VSS=VSS
+ VDD=VDD
Xg10391__9315 NAND2X1 $PINS Z=n_497 A=n_16 B=soc_can_tx_data_bus[22] VSS=VSS
+ VDD=VDD
Xg10392__9945 NAND2X1 $PINS Z=n_496 A=n_16 B=soc_can_tx_data_bus[23] VSS=VSS
+ VDD=VDD
Xg10393__2883 NAND2X1 $PINS Z=n_495 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[45] VSS=VSS VDD=VDD
Xg10394__2346 NAND2X1 $PINS Z=n_494 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[46] VSS=VSS VDD=VDD
Xg10395__1666 NAND2X1 $PINS Z=n_493 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[47] VSS=VSS VDD=VDD
Xg10396__7410 NAND2X1 $PINS Z=n_492 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[48] VSS=VSS VDD=VDD
Xg10397__6417 NAND2X1 $PINS Z=n_491 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[49] VSS=VSS VDD=VDD
Xg10398__5477 NAND2X1 $PINS Z=n_490 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[50] VSS=VSS VDD=VDD
Xg10399__2398 NAND2X1 $PINS Z=n_489 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[51] VSS=VSS VDD=VDD
Xg10400__5107 NAND2X1 $PINS Z=n_488 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[52] VSS=VSS VDD=VDD
Xg10401__6260 NAND2X1 $PINS Z=n_487 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[53] VSS=VSS VDD=VDD
Xg10402__4319 NAND2X1 $PINS Z=n_486 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[54] VSS=VSS VDD=VDD
Xg10403__8428 NAND2X1 $PINS Z=n_485 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[55] VSS=VSS VDD=VDD
Xg10404__5526 NAND3X1 $PINS Z=n_484 A=n_95 B=n_830 C=n_305 VSS=VSS VDD=VDD
Xg10405__6783 NAND2X1 $PINS Z=n_483 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[56] VSS=VSS VDD=VDD
Xg10406__3680 NAND2X1 $PINS Z=n_482 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[57] VSS=VSS VDD=VDD
Xg10407__1617 NAND2X1 $PINS Z=n_481 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[58] VSS=VSS VDD=VDD
Xg10408__2802 OR2X1 $PINS Z=n_480 A=n_193 B=n_14 VSS=VSS VDD=VDD
Xg10409__1705 NAND2X1 $PINS Z=n_479 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[59] VSS=VSS VDD=VDD
Xg10410__5122 NAND2X1 $PINS Z=n_478 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[60] VSS=VSS VDD=VDD
Xg10411__8246 NAND2X1 $PINS Z=n_477 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[61] VSS=VSS VDD=VDD
Xg10412__7098 NAND2X1 $PINS Z=n_476 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[62] VSS=VSS VDD=VDD
Xg10413__6131 NAND2X1 $PINS Z=n_475 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[63] VSS=VSS VDD=VDD
Xg10415__1881 NOR2X1 $PINS Z=n_577 A=soc_uart_rx_inst_state[0] B=n_349 VSS=VSS
+ VDD=VDD
Xg10420__5115 NAND2X1 $PINS Z=n_473 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[67] VSS=VSS VDD=VDD
Xg10421__7482 NAND2X1 $PINS Z=n_472 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[68] VSS=VSS VDD=VDD
Xg10422__4733 NAND2X1 $PINS Z=n_471 A=n_15 B=n_360 VSS=VSS VDD=VDD
Xg10423__6161 NAND2X1 $PINS Z=n_470 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[69] VSS=VSS VDD=VDD
Xg10424__9315 NAND2X1 $PINS Z=n_469 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[70] VSS=VSS VDD=VDD
Xg10425__9945 NAND2X1 $PINS Z=n_468 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[71] VSS=VSS VDD=VDD
Xg10426__2883 NAND3X1 $PINS Z=n_467 A=n_93 B=n_830 C=n_219 VSS=VSS VDD=VDD
Xg10427__2346 NAND2X1 $PINS Z=n_466 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[72] VSS=VSS VDD=VDD
Xg10428__1666 NAND2X1 $PINS Z=n_465 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[73] VSS=VSS VDD=VDD
Xg10429__7410 NAND2X1 $PINS Z=n_464 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[74] VSS=VSS VDD=VDD
Xg10430__6417 NAND2X1 $PINS Z=n_463 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[75] VSS=VSS VDD=VDD
Xg10431__5477 NAND2X1 $PINS Z=n_462 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[76] VSS=VSS VDD=VDD
Xg10432__2398 NAND2X1 $PINS Z=n_461 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[77] VSS=VSS VDD=VDD
Xg10433__5107 OR2X1 $PINS Z=n_460 A=n_111 B=n_14 VSS=VSS VDD=VDD
Xg10434__6260 NAND2X1 $PINS Z=n_459 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[78] VSS=VSS VDD=VDD
Xg10435__4319 NAND2X1 $PINS Z=n_458 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[79] VSS=VSS VDD=VDD
Xg10436__8428 NAND2X1 $PINS Z=n_457 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[80] VSS=VSS VDD=VDD
Xg10437__5526 NAND2X1 $PINS Z=n_456 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[81] VSS=VSS VDD=VDD
Xg10438__6783 NAND2X1 $PINS Z=n_455 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[82] VSS=VSS VDD=VDD
Xg10439__3680 NAND2X1 $PINS Z=n_454 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[83] VSS=VSS VDD=VDD
Xg10440__1617 OR2X1 $PINS Z=n_453 A=n_14 B=n_110 VSS=VSS VDD=VDD
Xg10441__2802 NAND2X1 $PINS Z=n_452 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[84] VSS=VSS VDD=VDD
Xg10442__1705 NAND2X1 $PINS Z=n_451 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[85] VSS=VSS VDD=VDD
Xg10443__5122 NAND2X1 $PINS Z=n_450 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[86] VSS=VSS VDD=VDD
Xg10444__8246 NAND2X1 $PINS Z=n_449 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[87] VSS=VSS VDD=VDD
Xg10445__7098 NAND2X1 $PINS Z=n_448 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[88] VSS=VSS VDD=VDD
Xg10446__6131 NAND2X1 $PINS Z=n_447 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[89] VSS=VSS VDD=VDD
Xg10447__1881 NAND2X1 $PINS Z=n_446 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[90] VSS=VSS VDD=VDD
Xg10448__5115 NAND2X1 $PINS Z=n_445 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[91] VSS=VSS VDD=VDD
Xg10449__7482 NAND2X1 $PINS Z=n_444 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[92] VSS=VSS VDD=VDD
Xg10450__4733 NAND2X1 $PINS Z=n_443 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[93] VSS=VSS VDD=VDD
Xg10451__6161 NAND2X1 $PINS Z=n_442 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[94] VSS=VSS VDD=VDD
Xg10452__9315 NAND2X1 $PINS Z=n_441 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[95] VSS=VSS VDD=VDD
Xg10453__9945 NAND2X1 $PINS Z=n_440 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[96] VSS=VSS VDD=VDD
Xg10454__2883 NAND2X1 $PINS Z=n_439 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[97] VSS=VSS VDD=VDD
Xg10455__2346 NAND2X1 $PINS Z=n_438 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[98] VSS=VSS VDD=VDD
Xg10456__1666 NAND2X1 $PINS Z=n_437 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[100] VSS=VSS VDD=VDD
Xg10457__7410 NAND2X1 $PINS Z=n_436 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[101] VSS=VSS VDD=VDD
Xg10458__6417 NAND2X1 $PINS Z=n_435 A=n_17 B=n_82 VSS=VSS VDD=VDD
Xg10460__2398 NAND2X1 $PINS Z=n_433 A=n_352 B=soc_can_tx_inst_status_reg[2]
+ VSS=VSS VDD=VDD
Xg10461__5107 NAND3X1 $PINS Z=n_432 A=n_92 B=n_830 C=n_220 VSS=VSS VDD=VDD
Xg10462__6260 XOR2X1 $PINS Z=n_431 A=soc_can_rx_inst_bit_count[6] B=n_109
+ VSS=VSS VDD=VDD
Xg10463__4319 NAND3X1 $PINS Z=n_430 A=n_334 B=n_317 C=n_83 VSS=VSS VDD=VDD
Xg10464__8428 OR2X1 $PINS Z=n_429 A=n_62 B=n_366 VSS=VSS VDD=VDD
Xg10465__5526 NAND2X1 $PINS Z=n_428 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[12] VSS=VSS VDD=VDD
Xg10466__6783 NAND2X1 $PINS Z=n_427 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[13] VSS=VSS VDD=VDD
Xg10467__3680 NAND2X1 $PINS Z=n_426 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[14] VSS=VSS VDD=VDD
Xg10468__1617 AND2X1 $PINS Z=n_425 A=n_359 B=n_830 VSS=VSS VDD=VDD
Xg10469__2802 NAND2X1 $PINS Z=n_424 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[15] VSS=VSS VDD=VDD
Xg10470__1705 NAND3X1 $PINS Z=n_423 A=n_89 B=n_830 C=n_221 VSS=VSS VDD=VDD
Xg10471__5122 NAND2X1 $PINS Z=n_422 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[16] VSS=VSS VDD=VDD
Xg10472__8246 NAND2X1 $PINS Z=n_421 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[17] VSS=VSS VDD=VDD
Xg10473__7098 NAND2X1 $PINS Z=n_420 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[18] VSS=VSS VDD=VDD
Xg10474__6131 NAND2X1 $PINS Z=n_419 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[19] VSS=VSS VDD=VDD
Xg10475__1881 NAND3X1 $PINS Z=n_418 A=n_88 B=n_830 C=n_223 VSS=VSS VDD=VDD
Xg10476__5115 NAND2X1 $PINS Z=n_417 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[20] VSS=VSS VDD=VDD
Xg10477__7482 NAND2X1 $PINS Z=n_416 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[21] VSS=VSS VDD=VDD
Xg10478__4733 NAND2X1 $PINS Z=n_415 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[22] VSS=VSS VDD=VDD
Xg10479__6161 NAND3X1 $PINS Z=n_414 A=n_94 B=n_830 C=n_218 VSS=VSS VDD=VDD
Xg10480__9315 NAND2X1 $PINS Z=n_413 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[23] VSS=VSS VDD=VDD
Xg10481__9945 NAND3X1 $PINS Z=n_412 A=n_96 B=n_830 C=n_238 VSS=VSS VDD=VDD
Xg10482__2883 NAND2X1 $PINS Z=n_411 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[11] VSS=VSS VDD=VDD
Xg10483__2346 NAND2X1 $PINS Z=n_410 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[24] VSS=VSS VDD=VDD
Xg10484__1666 NAND2X1 $PINS Z=n_409 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[25] VSS=VSS VDD=VDD
Xg10485__7410 NAND2X1 $PINS Z=n_408 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[26] VSS=VSS VDD=VDD
Xg10486__6417 NAND3X1 $PINS Z=n_407 A=n_91 B=n_830 C=n_209 VSS=VSS VDD=VDD
Xg10487__5477 NAND2X1 $PINS Z=n_406 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[27] VSS=VSS VDD=VDD
Xg10488__2398 NAND2X1 $PINS Z=n_405 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[28] VSS=VSS VDD=VDD
Xg10489__5107 NAND2X1 $PINS Z=n_404 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[29] VSS=VSS VDD=VDD
Xg10490__6260 NAND2X1 $PINS Z=n_403 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[30] VSS=VSS VDD=VDD
Xg10491__4319 NAND2X1 $PINS Z=n_402 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[31] VSS=VSS VDD=VDD
Xg10492__8428 NAND2X1 $PINS Z=n_401 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[32] VSS=VSS VDD=VDD
Xg10493__5526 NAND2X1 $PINS Z=n_400 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[33] VSS=VSS VDD=VDD
Xg10494__6783 NAND2X1 $PINS Z=n_399 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[34] VSS=VSS VDD=VDD
Xg10495__3680 NAND2X1 $PINS Z=n_398 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[35] VSS=VSS VDD=VDD
Xg10496__1617 NAND2X1 $PINS Z=n_397 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[36] VSS=VSS VDD=VDD
Xg10497__2802 NAND2X1 $PINS Z=n_396 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[37] VSS=VSS VDD=VDD
Xg10498__1705 NAND2X1 $PINS Z=n_395 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[38] VSS=VSS VDD=VDD
Xg10499__5122 NAND2X1 $PINS Z=n_394 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[39] VSS=VSS VDD=VDD
Xg10500__8246 NAND2X1 $PINS Z=n_393 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[40] VSS=VSS VDD=VDD
Xg10501__7098 NAND2X1 $PINS Z=n_392 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[41] VSS=VSS VDD=VDD
Xg10502__6131 NAND2X1 $PINS Z=n_391 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[42] VSS=VSS VDD=VDD
Xg10503__1881 NAND2X1 $PINS Z=n_390 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[43] VSS=VSS VDD=VDD
Xg10504__5115 NAND2X1 $PINS Z=n_389 A=FE_DBTN0_n_329
+ B=soc_can_tx_inst_shift_reg[44] VSS=VSS VDD=VDD
Xg10505__7482 NAND2X1 $PINS Z=n_388 A=n_363 B=n_242 VSS=VSS VDD=VDD
Xg10506__4733 NAND2X1 $PINS Z=n_387 A=n_337 B=soc_can_tx_inst_state[1] VSS=VSS
+ VDD=VDD
Xg10507__6161 NAND3X1 $PINS Z=n_386 A=n_17 B=n_250 C=n_78 VSS=VSS VDD=VDD
Xg10508__9315 NAND3X1 $PINS Z=n_385 A=n_17 B=n_247 C=n_77 VSS=VSS VDD=VDD
Xg10509__9945 NAND3X1 $PINS Z=n_384 A=n_17 B=n_246 C=n_81 VSS=VSS VDD=VDD
Xg10510__2883 NAND3X1 $PINS Z=n_383 A=n_17 B=n_245 C=n_80 VSS=VSS VDD=VDD
Xg10511__2346 NAND3X1 $PINS Z=n_382 A=n_17 B=n_244 C=n_79 VSS=VSS VDD=VDD
Xg10512__1666 NAND3X1 $PINS Z=n_381 A=n_108 B=n_107 C=n_190 VSS=VSS VDD=VDD
Xg10513__7410 NAND3X1 $PINS Z=n_380 A=n_17 B=n_232 C=n_76 VSS=VSS VDD=VDD
Xg10514__6417 NOR2X1 $PINS Z=n_379 A=n_339 B=n_366 VSS=VSS VDD=VDD
Xg10515__5477 MUX2X1 $PINS Z=n_378 A=n_188 B=soc_uart_tx_inst_Status_reg[1]
+ S=n_104 VSS=VSS VDD=VDD
Xg10516__2398 MUX2X1 $PINS Z=n_377 A=soc_uart_rx_inst_shift_reg[8]
+ B=soc_uart_rx_inst_shift_reg[9] S=n_321 VSS=VSS VDD=VDD
Xg10517__5107 MUX2X1 $PINS Z=n_376 A=soc_uart_rx_inst_shift_reg[5]
+ B=soc_uart_rx_inst_shift_reg[6] S=n_321 VSS=VSS VDD=VDD
Xg10518__6260 MUX2X1 $PINS Z=n_375 A=soc_uart_rx_inst_shift_reg[1]
+ B=soc_uart_rx_inst_shift_reg[2] S=n_321 VSS=VSS VDD=VDD
Xg10519__4319 MUX2X1 $PINS Z=n_374 A=soc_uart_rx_inst_shift_reg[2]
+ B=soc_uart_rx_inst_shift_reg[3] S=n_321 VSS=VSS VDD=VDD
Xg10520__8428 MUX2X1 $PINS Z=n_373 A=soc_uart_rx_inst_shift_reg[3]
+ B=soc_uart_rx_inst_shift_reg[4] S=n_321 VSS=VSS VDD=VDD
Xg10521__5526 MUX2X1 $PINS Z=n_372 A=soc_uart_rx_inst_shift_reg[4]
+ B=soc_uart_rx_inst_shift_reg[5] S=n_321 VSS=VSS VDD=VDD
Xg10522__6783 MUX2X1 $PINS Z=n_371 A=soc_uart_rx_inst_shift_reg[6]
+ B=soc_uart_rx_inst_shift_reg[7] S=n_321 VSS=VSS VDD=VDD
Xg10523__3680 MUX2X1 $PINS Z=n_370 A=soc_uart_rx_inst_shift_reg[7]
+ B=soc_uart_rx_inst_shift_reg[8] S=n_321 VSS=VSS VDD=VDD
Xg10524__1617 MUX2X1 $PINS Z=n_369 A=soc_uart_rx_inst_shift_reg[9] B=ser_rx_PAD
+ S=n_321 VSS=VSS VDD=VDD
Xg10525__2802 MUX2X1 $PINS Z=n_368 A=n_321 B=n_239
+ S=soc_uart_rx_inst_bit_count[0] VSS=VSS VDD=VDD
Xg10526__1705 XOR2X1 $PINS Z=n_367 A=soc_uart_tx_inst_Status_reg[3] B=n_324
+ VSS=VSS VDD=VDD
Xg10527__5122 NAND2X1 $PINS Z=n_474 A=n_17 B=n_831 VSS=VSS VDD=VDD
Xg10590 INVX4 $PINS Z=n_17 A=n_16 VSS=VSS VDD=VDD
Xg10598 INVX8 $PINS Z=n_15 A=n_14 VSS=VSS VDD=VDD
Xg10599__8246 XOR2X1 $PINS Z=n_360 A=soc_can_rx_inst_bit_count[3] B=n_75
+ VSS=VSS VDD=VDD
Xg10600__7098 XOR2X1 $PINS Z=n_359 A=soc_uart_tx_inst_Status_reg[0] B=n_105
+ VSS=VSS VDD=VDD
Xg10601__6131 MUX2X1 $PINS Z=n_358 A=n_13 B=n_5 S=soc_can_tx_inst_status_reg[0]
+ VSS=VSS VDD=VDD
Xg10602__1881 MUX2X1 $PINS Z=n_357 A=soc_uart_tx_inst_shift_reg[1]
+ B=soc_uart_tx_inst_shift_reg[0] S=n_104 VSS=VSS VDD=VDD
Xg10603__5115 NOR2X1 $PINS Z=n_356 A=n_313 B=n_327 VSS=VSS VDD=VDD
Xg10604__7482 NOR2X1 $PINS Z=n_355 A=n_314 B=n_324 VSS=VSS VDD=VDD
Xg10605__4733 NAND3X1 $PINS Z=n_354 A=n_105 B=n_319
+ C=soc_uart_tx_inst_Status_reg[3] VSS=VSS VDD=VDD
Xg10606__6161 NAND2X1 $PINS Z=n_353 A=n_104 B=n_189 VSS=VSS VDD=VDD
Xg10607__9315 NAND2X1 $PINS Z=n_352 A=n_312 B=soc_can_tx_inst_state[1] VSS=VSS
+ VDD=VDD
Xg10608__9945 OR2X1 $PINS Z=n_351 A=n_326 B=n_191 VSS=VSS VDD=VDD
Xg10610__2346 AND2X1 $PINS Z=n_349 A=n_326 B=soc_uart_rx_inst_state[1] VSS=VSS
+ VDD=VDD
Xg10613__6417 NAND2X1 $PINS Z=n_346 A=n_13 B=n_302 VSS=VSS VDD=VDD
Xg10614__5477 NAND2X1 $PINS Z=n_345 A=n_71 B=n_192 VSS=VSS VDD=VDD
Xg10615__2398 NAND2X1 $PINS Z=n_344 A=n_217 B=soc_can_rx_inst_bit_count[6]
+ VSS=VSS VDD=VDD
Xg10616__5107 NAND2X1 $PINS Z=n_343 A=n_217 B=soc_can_rx_inst_bit_count[5]
+ VSS=VSS VDD=VDD
Xg10617__6260 NAND2X1 $PINS Z=n_342 A=n_217 B=soc_can_rx_inst_bit_count[4]
+ VSS=VSS VDD=VDD
Xg10618__4319 NAND3X1 $PINS Z=n_341 A=n_271 B=n_32
+ C=soc_can_rx_inst_bit_count[6] VSS=VSS VDD=VDD
Xg10619__8428 NAND2X1 $PINS Z=n_340 A=n_323 B=soc_can_tx_inst_status_reg[3]
+ VSS=VSS VDD=VDD
Xg10620__5526 NOR2X1 $PINS Z=n_339 A=soc_can_index[2] B=n_327 VSS=VSS VDD=VDD
Xg10621__6783 NAND2X1 $PINS Z=n_338 A=n_196 B=n_22 VSS=VSS VDD=VDD
Xg10622__3680 NAND2X1 $PINS Z=n_337 A=n_322 B=n_7 VSS=VSS VDD=VDD
Xg10624__2802 NAND2X1 $PINS Z=n_335 A=n_217 B=soc_can_rx_inst_bit_count[3]
+ VSS=VSS VDD=VDD
Xg10625__1705 NAND2X1 $PINS Z=n_334 A=n_321 B=soc_uart_rx_inst_bit_count[3]
+ VSS=VSS VDD=VDD
Xg10626__5122 NAND2X1 $PINS Z=n_333 A=n_11 B=n_195 VSS=VSS VDD=VDD
Xg10627__8246 NAND2X1 $PINS Z=n_332 A=n_217 B=soc_can_rx_inst_bit_count[1]
+ VSS=VSS VDD=VDD
Xg10628__7098 NAND2X1 $PINS Z=n_331 A=n_84 B=n_194 VSS=VSS VDD=VDD
Xg10629__6131 NAND2X1 $PINS Z=n_330 A=n_217 B=soc_can_rx_inst_bit_count[2]
+ VSS=VSS VDD=VDD
Xg10641__1881 AND2X1 $PINS Z=n_366 A=n_327 B=soc_can_index[2] VSS=VSS VDD=VDD
Xg10645__5115 NOR2X1 $PINS Z=n_365 A=n_322 B=n_241 VSS=VSS VDD=VDD
Xg10650__7482 NAND2X1 $PINS Z=n_364 A=n_240 B=n_7 VSS=VSS VDD=VDD
Xg10651__4733 NAND3X1 $PINS Z=n_363 A=soc_uart_rx_inst_state[1]
+ B=soc_uart_rx_inst_state[0] C=n_39 VSS=VSS VDD=VDD
Xg10652__6161 NOR2X1 $PINS Z=n_16 A=soc_can_tx_inst_state[1] B=n_328 VSS=VSS
+ VDD=VDD
Xg10653__9315 NAND2X1 $PINS Z=n_329 A=n_328 B=n_5 VSS=VSS VDD=VDD
Xg10654__9945 NAND3X1 $PINS Z=n_14 A=n_840 B=n_72 C=rbyte_PAD VSS=VSS VDD=VDD
Xg10656 INVX2 $PINS Z=n_322 A=n_323 VSS=VSS VDD=VDD
Xg10657__2883 NAND2X1 $PINS Z=n_320 A=n_13 B=soc_can_tx_inst_shift_reg[82]
+ VSS=VSS VDD=VDD
Xg10658__2346 OR2X1 $PINS Z=n_319 A=soc_uart_tx_inst_Status_reg[0] B=n_99
+ VSS=VSS VDD=VDD
Xg10659__1666 NAND2X1 $PINS Z=n_318 A=n_13 B=soc_can_tx_inst_shift_reg[28]
+ VSS=VSS VDD=VDD
Xg10660__7410 NAND3X1 $PINS Z=n_317 A=n_30 B=n_22 C=n_27 VSS=VSS VDD=VDD
Xg10661__6417 NAND2X1 $PINS Z=n_316 A=n_13 B=soc_can_tx_inst_shift_reg[27]
+ VSS=VSS VDD=VDD
Xg10663__2398 NOR2X1 $PINS Z=n_314 A=soc_uart_tx_inst_Status_reg[2] B=n_64
+ VSS=VSS VDD=VDD
Xg10664__5107 NOR2X1 $PINS Z=n_313 A=soc_can_index[1] B=n_68 VSS=VSS VDD=VDD
Xg10665__6260 NAND2X1 $PINS Z=n_312 A=n_7 B=n_66 VSS=VSS VDD=VDD
Xg10666__4319 AND2X1 $PINS Z=n_311 A=n_71 B=n_7 VSS=VSS VDD=VDD
Xg10667__8428 NAND2X1 $PINS Z=n_310 A=n_13 B=soc_can_tx_inst_shift_reg[45]
+ VSS=VSS VDD=VDD
Xg10668__5526 NAND2X1 $PINS Z=n_309 A=n_13 B=soc_can_tx_inst_shift_reg[46]
+ VSS=VSS VDD=VDD
Xg10669__6783 NAND2X1 $PINS Z=n_308 A=n_13 B=soc_can_tx_inst_shift_reg[47]
+ VSS=VSS VDD=VDD
Xg10670__3680 NAND2X1 $PINS Z=n_307 A=n_13 B=soc_can_tx_inst_shift_reg[13]
+ VSS=VSS VDD=VDD
Xg10671__1617 NAND2X1 $PINS Z=n_306 A=n_13 B=soc_can_tx_inst_shift_reg[48]
+ VSS=VSS VDD=VDD
Xg10672__2802 AND2X1 $PINS Z=n_305 A=n_47 B=n_100 VSS=VSS VDD=VDD
Xg10673__1705 NAND2X1 $PINS Z=n_304 A=n_13 B=soc_can_tx_inst_shift_reg[49]
+ VSS=VSS VDD=VDD
Xg10674__5122 NAND2X1 $PINS Z=n_303 A=n_13 B=soc_can_tx_inst_shift_reg[50]
+ VSS=VSS VDD=VDD
Xg10675__8246 NOR2X1 $PINS Z=n_302 A=soc_can_tx_inst_status_reg[2] B=n_66
+ VSS=VSS VDD=VDD
Xg10676__7098 NAND2X1 $PINS Z=n_301 A=n_13 B=soc_can_tx_inst_shift_reg[51]
+ VSS=VSS VDD=VDD
Xg10677__6131 OR2X1 $PINS Z=n_300 A=n_102 B=n_67 VSS=VSS VDD=VDD
Xg10678__1881 NAND2X1 $PINS Z=n_299 A=n_13 B=soc_can_tx_inst_shift_reg[52]
+ VSS=VSS VDD=VDD
Xg10679__5115 NAND2X1 $PINS Z=n_298 A=n_13 B=soc_can_tx_inst_shift_reg[53]
+ VSS=VSS VDD=VDD
Xg10680__7482 NAND2X1 $PINS Z=n_297 A=n_13 B=soc_can_tx_inst_shift_reg[54]
+ VSS=VSS VDD=VDD
Xg10681__4733 NAND2X1 $PINS Z=n_296 A=n_13 B=soc_can_tx_inst_shift_reg[55]
+ VSS=VSS VDD=VDD
Xg10682__6161 NAND2X1 $PINS Z=n_295 A=n_13 B=soc_can_tx_inst_shift_reg[56]
+ VSS=VSS VDD=VDD
Xg10683__9315 NAND2X1 $PINS Z=n_294 A=n_60 B=soc_can_tx_inst_state[1] VSS=VSS
+ VDD=VDD
Xg10684__9945 NAND2X1 $PINS Z=n_293 A=n_13 B=soc_can_tx_inst_shift_reg[57]
+ VSS=VSS VDD=VDD
Xg10685__2883 NAND2X1 $PINS Z=n_292 A=n_13 B=soc_can_tx_inst_shift_reg[18]
+ VSS=VSS VDD=VDD
Xg10686__2346 NAND2X1 $PINS Z=n_291 A=n_13 B=soc_can_tx_inst_shift_reg[58]
+ VSS=VSS VDD=VDD
Xg10687__1666 NAND2X1 $PINS Z=n_290 A=n_13 B=soc_can_tx_inst_shift_reg[59]
+ VSS=VSS VDD=VDD
Xg10688__7410 NAND2X1 $PINS Z=n_289 A=n_13 B=soc_can_tx_inst_shift_reg[60]
+ VSS=VSS VDD=VDD
Xg10689__6417 NAND2X1 $PINS Z=n_288 A=n_13 B=soc_can_tx_inst_shift_reg[61]
+ VSS=VSS VDD=VDD
Xg10690__5477 NAND2X1 $PINS Z=n_287 A=n_13 B=soc_can_tx_inst_shift_reg[62]
+ VSS=VSS VDD=VDD
Xg10691__2398 NAND2X1 $PINS Z=n_286 A=n_13 B=soc_can_tx_inst_shift_reg[63]
+ VSS=VSS VDD=VDD
Xg10692__5107 NAND2X1 $PINS Z=n_285 A=n_13 B=soc_can_tx_inst_shift_reg[64]
+ VSS=VSS VDD=VDD
Xg10693__6260 NAND2X1 $PINS Z=n_284 A=n_13 B=soc_can_tx_inst_shift_reg[26]
+ VSS=VSS VDD=VDD
Xg10694__4319 NAND2X1 $PINS Z=n_283 A=n_13 B=soc_can_tx_inst_shift_reg[65]
+ VSS=VSS VDD=VDD
Xg10695__8428 NAND2X1 $PINS Z=n_282 A=n_13 B=soc_can_tx_inst_shift_reg[66]
+ VSS=VSS VDD=VDD
Xg10696__5526 NAND2X1 $PINS Z=n_281 A=n_13 B=soc_can_tx_inst_shift_reg[24]
+ VSS=VSS VDD=VDD
Xg10697__6783 NAND2X1 $PINS Z=n_280 A=n_13 B=soc_can_tx_inst_shift_reg[68]
+ VSS=VSS VDD=VDD
Xg10698__3680 NAND2X1 $PINS Z=n_279 A=n_13 B=soc_can_tx_inst_shift_reg[69]
+ VSS=VSS VDD=VDD
Xg10699__1617 NAND2X1 $PINS Z=n_278 A=n_13 B=soc_can_tx_inst_shift_reg[70]
+ VSS=VSS VDD=VDD
Xg10700__2802 NAND2X1 $PINS Z=n_277 A=n_13 B=soc_can_tx_inst_shift_reg[71]
+ VSS=VSS VDD=VDD
Xg10701__1705 NAND2X1 $PINS Z=n_276 A=n_13 B=soc_can_tx_inst_shift_reg[72]
+ VSS=VSS VDD=VDD
Xg10702__5122 NAND2X1 $PINS Z=n_275 A=n_13 B=soc_can_tx_inst_shift_reg[73]
+ VSS=VSS VDD=VDD
Xg10703__8246 NAND2X1 $PINS Z=n_274 A=n_13 B=soc_can_tx_inst_shift_reg[75]
+ VSS=VSS VDD=VDD
Xg10704__7098 NAND2X1 $PINS Z=n_273 A=n_13 B=soc_can_tx_inst_shift_reg[22]
+ VSS=VSS VDD=VDD
Xg10705__6131 NAND2X1 $PINS Z=n_272 A=n_13 B=soc_can_tx_inst_shift_reg[76]
+ VSS=VSS VDD=VDD
Xg10706__1881 NAND3X1 $PINS Z=n_271 A=n_845 B=n_31 C=n_24 VSS=VSS VDD=VDD
Xg10707__5115 NAND2X1 $PINS Z=n_270 A=n_13 B=soc_can_tx_inst_shift_reg[78]
+ VSS=VSS VDD=VDD
Xg10708__7482 NAND2X1 $PINS Z=n_269 A=n_13 B=soc_can_tx_inst_shift_reg[79]
+ VSS=VSS VDD=VDD
Xg10709__4733 NAND2X1 $PINS Z=n_268 A=n_13 B=soc_can_tx_inst_shift_reg[23]
+ VSS=VSS VDD=VDD
Xg10710__6161 NAND2X1 $PINS Z=n_267 A=n_13 B=soc_can_tx_inst_shift_reg[80]
+ VSS=VSS VDD=VDD
Xg10711__9315 NAND2X1 $PINS Z=n_266 A=n_13 B=soc_can_tx_inst_shift_reg[25]
+ VSS=VSS VDD=VDD
Xg10712__9945 NAND2X1 $PINS Z=n_265 A=n_13 B=soc_can_tx_inst_shift_reg[83]
+ VSS=VSS VDD=VDD
Xg10713__2883 NAND2X1 $PINS Z=n_264 A=n_13 B=soc_can_tx_inst_shift_reg[67]
+ VSS=VSS VDD=VDD
Xg10714__2346 NAND2X1 $PINS Z=n_263 A=n_13 B=soc_can_tx_inst_shift_reg[84]
+ VSS=VSS VDD=VDD
Xg10715__1666 NAND2X1 $PINS Z=n_262 A=n_13 B=soc_can_tx_inst_shift_reg[85]
+ VSS=VSS VDD=VDD
Xg10716__7410 NAND2X1 $PINS Z=n_261 A=n_13 B=soc_can_tx_inst_shift_reg[87]
+ VSS=VSS VDD=VDD
Xg10717__6417 NAND2X1 $PINS Z=n_260 A=n_13 B=soc_can_tx_inst_shift_reg[88]
+ VSS=VSS VDD=VDD
Xg10718__5477 NAND2X1 $PINS Z=n_259 A=n_13 B=soc_can_tx_inst_shift_reg[89]
+ VSS=VSS VDD=VDD
Xg10719__2398 NAND2X1 $PINS Z=n_258 A=n_13 B=soc_can_tx_inst_shift_reg[90]
+ VSS=VSS VDD=VDD
Xg10720__5107 NAND2X1 $PINS Z=n_257 A=n_13 B=soc_can_tx_inst_shift_reg[91]
+ VSS=VSS VDD=VDD
Xg10721__6260 NAND2X1 $PINS Z=n_256 A=n_13 B=soc_can_tx_inst_shift_reg[92]
+ VSS=VSS VDD=VDD
Xg10722__4319 NAND2X1 $PINS Z=n_255 A=n_13 B=soc_can_tx_inst_shift_reg[93]
+ VSS=VSS VDD=VDD
Xg10723__8428 NAND2X1 $PINS Z=n_254 A=n_13 B=soc_can_tx_inst_shift_reg[95]
+ VSS=VSS VDD=VDD
Xg10724__5526 NAND2X1 $PINS Z=n_253 A=n_13 B=soc_can_tx_inst_shift_reg[96]
+ VSS=VSS VDD=VDD
Xg10725__6783 NAND2X1 $PINS Z=n_252 A=n_13 B=soc_can_tx_inst_shift_reg[97]
+ VSS=VSS VDD=VDD
Xg10726__3680 NAND2X1 $PINS Z=n_251 A=n_13 B=soc_can_tx_inst_shift_reg[99]
+ VSS=VSS VDD=VDD
Xg10727__1617 NAND2X1 $PINS Z=n_250 A=n_13 B=soc_can_tx_inst_shift_reg[100]
+ VSS=VSS VDD=VDD
Xg10728__2802 NAND2X1 $PINS Z=n_249 A=n_13 B=soc_can_tx_inst_shift_reg[101]
+ VSS=VSS VDD=VDD
Xg10729__1705 NAND2X1 $PINS Z=n_248 A=n_13 B=soc_can_tx_inst_shift_reg[15]
+ VSS=VSS VDD=VDD
Xg10730__5122 NAND2X1 $PINS Z=n_247 A=n_13 B=soc_can_tx_inst_shift_reg[103]
+ VSS=VSS VDD=VDD
Xg10731__8246 NAND2X1 $PINS Z=n_246 A=n_13 B=soc_can_tx_inst_shift_reg[104]
+ VSS=VSS VDD=VDD
Xg10732__7098 NAND2X1 $PINS Z=n_245 A=n_13 B=soc_can_tx_inst_shift_reg[105]
+ VSS=VSS VDD=VDD
Xg10733__6131 NAND2X1 $PINS Z=n_244 A=n_13 B=soc_can_tx_inst_shift_reg[106]
+ VSS=VSS VDD=VDD
Xg10735__5115 NAND2X1 $PINS Z=n_242 A=n_48 B=soc_uart_data_ready VSS=VSS
+ VDD=VDD
Xg10736__7482 NAND2X1 $PINS Z=n_241 A=n_13 B=soc_can_tx_inst_status_reg[3]
+ VSS=VSS VDD=VDD
Xg10737__4733 NAND2X1 $PINS Z=n_240 A=n_5 B=n_73 VSS=VSS VDD=VDD
Xg10738__6161 NAND2X1 $PINS Z=n_239 A=n_108 B=n_22 VSS=VSS VDD=VDD
Xg10739__9315 AND2X1 $PINS Z=n_238 A=n_85 B=n_101 VSS=VSS VDD=VDD
Xg10741__2883 NAND2X1 $PINS Z=n_236 A=n_13 B=soc_can_tx_inst_shift_reg[77]
+ VSS=VSS VDD=VDD
Xg10742__2346 NOR2X1 $PINS Z=n_235 A=soc_can_tx_inst_status_reg[6] B=n_71
+ VSS=VSS VDD=VDD
Xg10743__1666 NAND2X1 $PINS Z=n_234 A=n_13 B=soc_can_tx_inst_shift_reg[19]
+ VSS=VSS VDD=VDD
Xg10744__7410 NAND2X1 $PINS Z=n_233 A=n_13 B=soc_can_tx_inst_shift_reg[81]
+ VSS=VSS VDD=VDD
Xg10745__6417 NAND2X1 $PINS Z=n_232 A=n_13 B=soc_can_tx_inst_shift_reg[11]
+ VSS=VSS VDD=VDD
Xg10746__5477 NAND2X1 $PINS Z=n_231 A=n_13 B=soc_can_tx_inst_shift_reg[94]
+ VSS=VSS VDD=VDD
Xg10747__2398 NAND2X1 $PINS Z=n_230 A=n_13 B=soc_can_tx_inst_shift_reg[86]
+ VSS=VSS VDD=VDD
Xg10748__5107 NAND2X1 $PINS Z=n_229 A=n_13 B=soc_can_tx_inst_shift_reg[12]
+ VSS=VSS VDD=VDD
Xg10749__6260 NAND2X1 $PINS Z=n_228 A=n_13 B=soc_can_tx_inst_shift_reg[14]
+ VSS=VSS VDD=VDD
Xg10750__4319 NAND2X1 $PINS Z=n_227 A=n_13 B=soc_can_tx_inst_shift_reg[16]
+ VSS=VSS VDD=VDD
Xg10751__8428 NAND2X1 $PINS Z=n_226 A=n_13 B=soc_can_tx_inst_shift_reg[17]
+ VSS=VSS VDD=VDD
Xg10752__5526 NAND2X1 $PINS Z=n_225 A=n_13 B=soc_can_tx_inst_shift_reg[20]
+ VSS=VSS VDD=VDD
Xg10753__6783 NAND2X1 $PINS Z=n_224 A=n_13 B=soc_can_tx_inst_shift_reg[21]
+ VSS=VSS VDD=VDD
Xg10754__3680 AND2X1 $PINS Z=n_223 A=n_43 B=n_55 VSS=VSS VDD=VDD
Xg10755__1617 NAND2X1 $PINS Z=n_222 A=n_13 B=soc_can_tx_inst_shift_reg[102]
+ VSS=VSS VDD=VDD
Xg10756__2802 AND2X1 $PINS Z=n_221 A=n_40 B=n_52 VSS=VSS VDD=VDD
Xg10757__1705 AND2X1 $PINS Z=n_220 A=n_53 B=n_59 VSS=VSS VDD=VDD
Xg10758__5122 AND2X1 $PINS Z=n_219 A=n_51 B=n_41 VSS=VSS VDD=VDD
Xg10759__8246 AND2X1 $PINS Z=n_218 A=n_58 B=n_57 VSS=VSS VDD=VDD
Xg10760__7098 NAND2X1 $PINS Z=n_328 A=n_74 B=n_7 VSS=VSS VDD=VDD
Xg10761__6131 AND2X1 $PINS Z=n_327 A=n_68 B=soc_can_index[1] VSS=VSS VDD=VDD
Xg10762__1881 NAND2X1 $PINS Z=n_326 A=n_69 B=soc_uart_rx_inst_bit_count[1]
+ VSS=VSS VDD=VDD
Xg10763__5115 AND2X1 $PINS Z=n_324 A=n_64 B=soc_uart_tx_inst_Status_reg[2]
+ VSS=VSS VDD=VDD
Xg10764__7482 AND2X1 $PINS Z=n_323 A=n_65 B=soc_can_tx_inst_status_reg[2]
+ VSS=VSS VDD=VDD
Xg10765__4733 NOR2X1 $PINS Z=n_321 A=n_23 B=n_107 VSS=VSS VDD=VDD
Xg10766__6161 MUX2X1 $PINS Z=n_216 A=soc_can_tx_data_bus[40]
+ B=soc_can_tx_data_bus[32] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10767__9315 NAND2X1 $PINS Z=n_215 A=n_13 B=soc_can_tx_inst_shift_reg[30]
+ VSS=VSS VDD=VDD
Xg10768__9945 NAND2X1 $PINS Z=n_214 A=n_13 B=soc_can_tx_inst_shift_reg[31]
+ VSS=VSS VDD=VDD
Xg10769__2883 NAND2X1 $PINS Z=n_213 A=n_13 B=soc_can_tx_inst_shift_reg[32]
+ VSS=VSS VDD=VDD
Xg10770__2346 NAND2X1 $PINS Z=n_212 A=n_13 B=soc_can_tx_inst_shift_reg[33]
+ VSS=VSS VDD=VDD
Xg10771__1666 NAND2X1 $PINS Z=n_211 A=n_13 B=soc_can_tx_inst_shift_reg[34]
+ VSS=VSS VDD=VDD
Xg10772__7410 NAND2X1 $PINS Z=n_210 A=n_13 B=soc_can_tx_inst_shift_reg[35]
+ VSS=VSS VDD=VDD
Xg10773__6417 AND2X1 $PINS Z=n_209 A=n_54 B=n_61 VSS=VSS VDD=VDD
Xg10774__5477 NAND2X1 $PINS Z=n_208 A=n_13 B=soc_can_tx_inst_shift_reg[74]
+ VSS=VSS VDD=VDD
Xg10775__2398 NAND2X1 $PINS Z=n_207 A=n_13 B=soc_can_tx_inst_shift_reg[36]
+ VSS=VSS VDD=VDD
Xg10776__5107 NAND2X1 $PINS Z=n_206 A=n_13 B=soc_can_tx_inst_shift_reg[37]
+ VSS=VSS VDD=VDD
Xg10777__6260 NAND2X1 $PINS Z=n_205 A=n_13 B=soc_can_tx_inst_shift_reg[38]
+ VSS=VSS VDD=VDD
Xg10778__4319 NAND2X1 $PINS Z=n_204 A=n_13 B=soc_can_tx_inst_shift_reg[39]
+ VSS=VSS VDD=VDD
Xg10779__8428 NAND2X1 $PINS Z=n_203 A=n_13 B=soc_can_tx_inst_shift_reg[40]
+ VSS=VSS VDD=VDD
Xg10780__5526 NAND2X1 $PINS Z=n_202 A=n_13 B=soc_can_tx_inst_shift_reg[98]
+ VSS=VSS VDD=VDD
Xg10781__6783 NAND2X1 $PINS Z=n_201 A=n_13 B=soc_can_tx_inst_shift_reg[41]
+ VSS=VSS VDD=VDD
Xg10782__3680 XOR2X1 $PINS Z=n_200 A=soc_can_rx_inst_bit_count[0]
+ B=soc_can_rx_inst_bit_count[1] VSS=VSS VDD=VDD
Xg10783__1617 NAND2X1 $PINS Z=n_199 A=n_13 B=soc_can_tx_inst_shift_reg[42]
+ VSS=VSS VDD=VDD
Xg10784__2802 NAND2X1 $PINS Z=n_198 A=n_13 B=soc_can_tx_inst_shift_reg[43]
+ VSS=VSS VDD=VDD
Xg10785__1705 NAND2X1 $PINS Z=n_197 A=n_13 B=soc_can_tx_inst_shift_reg[44]
+ VSS=VSS VDD=VDD
Xg10786__5122 NAND2X1 $PINS Z=n_196 A=soc_uart_rx_inst_state[1] B=n_70 VSS=VSS
+ VDD=VDD
Xg10787__8246 NAND3X1 $PINS Z=n_195 A=n_5 B=soc_can_tx_inst_state[0]
+ C=soc_Can_ID_Bus[0] VSS=VSS VDD=VDD
Xg10788__7098 NAND3X1 $PINS Z=n_194 A=soc_can_rx_inst_state[2]
+ B=soc_can_rx_inst_state[1] C=rbyte_PAD VSS=VSS VDD=VDD
Xg10789__6131 XOR2X1 $PINS Z=n_193 A=soc_can_rx_inst_bit_count[2] B=n_845
+ VSS=VSS VDD=VDD
Xg10790__1881 NAND3X1 $PINS Z=n_192 A=soc_can_tx_inst_status_reg[5]
+ B=soc_can_tx_inst_status_reg[3] C=n_45 VSS=VSS VDD=VDD
Xg10791__5115 NAND3X1 $PINS Z=n_191 A=n_106 B=soc_uart_rx_inst_bit_count[2]
+ C=n_34 VSS=VSS VDD=VDD
Xg10792__7482 NAND3X1 $PINS Z=n_190 A=n_30 B=soc_uart_rx_inst_state[0]
+ C=rbyte_PAD VSS=VSS VDD=VDD
Xg10793__4733 NAND3X1 $PINS Z=n_189 A=soc_uart_tx_inst_state[0] B=n_20
+ C=tbyte_PAD VSS=VSS VDD=VDD
Xg10794__6161 NOR2X1 $PINS Z=n_188 A=n_63 B=n_64 VSS=VSS VDD=VDD
Xg10795__9315 NOR2X1 $PINS Z=n_187 A=n_68 B=n_37 VSS=VSS VDD=VDD
Xg10796__9945 MUX2X1 $PINS Z=n_186 A=soc_can_tx_data_bus[20]
+ B=soc_can_tx_data_bus[12] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10797__2883 MUX2X1 $PINS Z=n_185 A=soc_can_tx_data_bus[6]
+ B=soc_uart_rx_data_bus[6] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10798__2346 MUX2X1 $PINS Z=n_184 A=soc_can_tx_data_bus[21]
+ B=soc_can_tx_data_bus[13] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10799__1666 MUX2X1 $PINS Z=n_183 A=soc_can_tx_data_bus[22]
+ B=soc_can_tx_data_bus[14] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10800__7410 MUX2X1 $PINS Z=n_182 A=soc_can_tx_data_bus[23]
+ B=soc_can_tx_data_bus[15] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10801__6417 MUX2X1 $PINS Z=n_181 A=soc_can_tx_data_bus[32]
+ B=soc_can_tx_data_bus[24] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10802__5477 MUX2X1 $PINS Z=n_180 A=soc_can_tx_data_bus[24]
+ B=soc_can_tx_data_bus[16] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10803__2398 MUX2X1 $PINS Z=n_179 A=soc_can_tx_data_bus[25]
+ B=soc_can_tx_data_bus[17] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10804__5107 MUX2X1 $PINS Z=n_178 A=soc_can_tx_data_bus[26]
+ B=soc_can_tx_data_bus[18] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10805__6260 MUX2X1 $PINS Z=n_177 A=soc_can_tx_data_bus[2]
+ B=soc_uart_rx_data_bus[2] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10806__4319 MUX2X1 $PINS Z=n_176 A=soc_can_tx_data_bus[27]
+ B=soc_can_tx_data_bus[19] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10807__8428 MUX2X1 $PINS Z=n_175 A=soc_can_tx_data_bus[38]
+ B=soc_can_tx_data_bus[30] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10808__5526 MUX2X1 $PINS Z=n_174 A=soc_can_tx_data_bus[29]
+ B=soc_can_tx_data_bus[21] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10809__6783 MUX2X1 $PINS Z=n_173 A=soc_can_tx_data_bus[44]
+ B=soc_can_tx_data_bus[36] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10810__3680 MUX2X1 $PINS Z=n_172 A=soc_can_tx_data_bus[30]
+ B=soc_can_tx_data_bus[22] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10811__1617 MUX2X1 $PINS Z=n_171 A=soc_can_tx_data_bus[31]
+ B=soc_can_tx_data_bus[23] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10812__2802 MUX2X1 $PINS Z=n_170 A=soc_can_tx_data_bus[62]
+ B=soc_can_tx_data_bus[54] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10813__1705 MUX2X1 $PINS Z=n_169 A=soc_can_tx_data_bus[33]
+ B=soc_can_tx_data_bus[25] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10814__5122 MUX2X1 $PINS Z=n_168 A=soc_can_tx_data_bus[34]
+ B=soc_can_tx_data_bus[26] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10815__8246 MUX2X1 $PINS Z=n_167 A=soc_can_tx_data_bus[35]
+ B=soc_can_tx_data_bus[27] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10816__7098 MUX2X1 $PINS Z=n_166 A=soc_can_tx_data_bus[37]
+ B=soc_can_tx_data_bus[29] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10817__6131 MUX2X1 $PINS Z=n_165 A=soc_can_tx_data_bus[61]
+ B=soc_can_tx_data_bus[53] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10818__1881 MUX2X1 $PINS Z=n_164 A=soc_can_tx_data_bus[1]
+ B=soc_uart_rx_data_bus[1] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10819__5115 MUX2X1 $PINS Z=n_163 A=soc_can_tx_data_bus[36]
+ B=soc_can_tx_data_bus[28] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10820__7482 NAND2X1 $PINS Z=n_162 A=n_13 B=soc_can_tx_inst_shift_reg[29]
+ VSS=VSS VDD=VDD
Xg10821__4733 MUX2X1 $PINS Z=n_161 A=soc_can_tx_data_bus[28]
+ B=soc_can_tx_data_bus[20] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10822__6161 MUX2X1 $PINS Z=n_160 A=soc_can_tx_data_bus[42]
+ B=soc_can_tx_data_bus[34] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10823__9315 MUX2X1 $PINS Z=n_159 A=soc_can_tx_data_bus[43]
+ B=soc_can_tx_data_bus[35] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10824__9945 MUX2X1 $PINS Z=n_158 A=soc_can_tx_data_bus[60]
+ B=soc_can_tx_data_bus[52] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10825__2883 MUX2X1 $PINS Z=n_157 A=soc_can_tx_data_bus[45]
+ B=soc_can_tx_data_bus[37] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10826__2346 MUX2X1 $PINS Z=n_156 A=soc_can_tx_data_bus[47]
+ B=soc_can_tx_data_bus[39] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10827__1666 MUX2X1 $PINS Z=n_155 A=soc_can_tx_data_bus[49]
+ B=soc_can_tx_data_bus[41] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10828__7410 MUX2X1 $PINS Z=n_154 A=soc_can_tx_data_bus[59]
+ B=soc_can_tx_data_bus[51] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10829__6417 MUX2X1 $PINS Z=n_153 A=soc_can_tx_data_bus[50]
+ B=soc_can_tx_data_bus[42] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10830__5477 MUX2X1 $PINS Z=n_152 A=soc_can_tx_data_bus[51]
+ B=soc_can_tx_data_bus[43] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10831__2398 MUX2X1 $PINS Z=n_151 A=soc_can_tx_data_bus[53]
+ B=soc_can_tx_data_bus[45] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10832__5107 MUX2X1 $PINS Z=n_150 A=soc_can_tx_data_bus[58]
+ B=soc_can_tx_data_bus[50] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10833__6260 MUX2X1 $PINS Z=n_149 A=soc_can_tx_data_bus[54]
+ B=soc_can_tx_data_bus[46] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10834__4319 MUX2X1 $PINS Z=n_148 A=soc_can_tx_data_bus[3]
+ B=soc_uart_rx_data_bus[3] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10835__8428 MUX2X1 $PINS Z=n_147 A=soc_can_tx_data_bus[63]
+ B=soc_can_tx_data_bus[55] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10836__5526 MUX2X1 $PINS Z=n_146 A=soc_can_tx_data_bus[57]
+ B=soc_can_tx_data_bus[49] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10837__6783 MUX2X1 $PINS Z=n_145 A=soc_can_tx_data_bus[5]
+ B=soc_uart_rx_data_bus[5] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10838__3680 MUX2X1 $PINS Z=n_144 A=soc_can_tx_data_bus[46]
+ B=soc_can_tx_data_bus[38] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10839__1617 MUX2X1 $PINS Z=n_143 A=soc_can_tx_data_bus[39]
+ B=soc_can_tx_data_bus[31] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10840__2802 MUX2X1 $PINS Z=n_142 A=soc_can_tx_data_bus[41]
+ B=soc_can_tx_data_bus[33] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10841__1705 MUX2X1 $PINS Z=n_141 A=soc_can_tx_data_bus[48]
+ B=soc_can_tx_data_bus[40] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10842__5122 MUX2X1 $PINS Z=n_140 A=soc_can_tx_data_bus[52]
+ B=soc_can_tx_data_bus[44] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10843__8246 MUX2X1 $PINS Z=n_139 A=soc_can_tx_data_bus[0]
+ B=soc_uart_rx_data_bus[0] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10844__7098 MUX2X1 $PINS Z=n_138 A=soc_can_tx_data_bus[56]
+ B=soc_can_tx_data_bus[48] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10845__6131 MUX2X1 $PINS Z=n_137 A=soc_can_tx_data_bus[19]
+ B=soc_can_tx_data_bus[11] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10846__1881 MUX2X1 $PINS Z=n_136 A=soc_can_tx_data_bus[7]
+ B=soc_uart_rx_data_bus[7] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10847__5115 MUX2X1 $PINS Z=n_135 A=soc_can_tx_data_bus[18]
+ B=soc_can_tx_data_bus[10] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10848__7482 MUX2X1 $PINS Z=n_134 A=soc_can_tx_data_bus[8]
+ B=soc_can_tx_data_bus[0] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10849__4733 MUX2X1 $PINS Z=n_133 A=soc_can_tx_data_bus[4]
+ B=soc_uart_rx_data_bus[4] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10850__6161 MUX2X1 $PINS Z=n_132 A=soc_can_tx_data_bus[9]
+ B=soc_can_tx_data_bus[1] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10851__9315 MUX2X1 $PINS Z=n_131 A=soc_can_tx_data_bus[55]
+ B=soc_can_tx_data_bus[47] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10852__9945 MUX2X1 $PINS Z=n_130 A=soc_can_tx_data_bus[10]
+ B=soc_can_tx_data_bus[2] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10853__2883 MUX2X1 $PINS Z=n_129 A=soc_can_tx_data_bus[11]
+ B=soc_can_tx_data_bus[3] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10854__2346 MUX2X1 $PINS Z=n_128 A=soc_can_tx_data_bus[12]
+ B=soc_can_tx_data_bus[4] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10855__1666 MUX2X1 $PINS Z=n_127 A=soc_can_tx_data_bus[13]
+ B=soc_can_tx_data_bus[5] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10856__7410 MUX2X1 $PINS Z=n_126 A=soc_can_tx_data_bus[14]
+ B=soc_can_tx_data_bus[6] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10857__6417 MUX2X1 $PINS Z=n_125 A=soc_can_tx_data_bus[15]
+ B=soc_can_tx_data_bus[7] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10858__5477 MUX2X1 $PINS Z=n_124 A=soc_can_tx_data_bus[16]
+ B=soc_can_tx_data_bus[8] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10859__2398 MUX2X1 $PINS Z=n_123 A=soc_can_tx_data_bus[17]
+ B=soc_can_tx_data_bus[9] S=soc_uart_data_ready VSS=VSS VDD=VDD
Xg10860__5107 MUX2X1 $PINS Z=n_122 A=soc_can_tx_inst_shift_reg[1]
+ B=soc_can_tx_inst_shift_reg[2] S=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10861__6260 MUX2X1 $PINS Z=n_121 A=soc_can_tx_inst_shift_reg[3]
+ B=soc_can_tx_inst_shift_reg[4] S=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10862__4319 MUX2X1 $PINS Z=n_120 A=soc_can_tx_inst_shift_reg[4]
+ B=soc_can_tx_inst_shift_reg[5] S=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10863__8428 MUX2X1 $PINS Z=n_119 A=soc_uart_tx_data_Bus[7]
+ B=soc_Can_rx_data_Bus[7] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10864__5526 MUX2X1 $PINS Z=n_118 A=soc_uart_tx_data_Bus[5]
+ B=soc_Can_rx_data_Bus[5] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10865__6783 MUX2X1 $PINS Z=n_117 A=soc_uart_tx_data_Bus[1]
+ B=soc_Can_rx_data_Bus[1] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10866__3680 MUX2X1 $PINS Z=n_116 A=soc_uart_tx_data_Bus[3]
+ B=soc_Can_rx_data_Bus[3] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10867__1617 MUX2X1 $PINS Z=n_115 A=soc_uart_tx_data_Bus[2]
+ B=soc_Can_rx_data_Bus[2] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10868__2802 MUX2X1 $PINS Z=n_114 A=soc_uart_tx_data_Bus[6]
+ B=soc_Can_rx_data_Bus[6] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10869__1705 MUX2X1 $PINS Z=n_113 A=soc_uart_tx_data_Bus[0]
+ B=soc_Can_rx_data_Bus[0] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10870__5122 MUX2X1 $PINS Z=n_112 A=soc_uart_tx_data_Bus[4]
+ B=soc_Can_rx_data_Bus[4] S=soc_can_data_ready VSS=VSS VDD=VDD
Xg10871__8246 XOR2X1 $PINS Z=n_111 A=soc_can_rx_inst_bit_count[4]
+ B=soc_can_rx_inst_n_1158 VSS=VSS VDD=VDD
Xg10872__7098 XOR2X1 $PINS Z=n_110 A=soc_can_rx_inst_bit_count[5]
+ B=soc_can_rx_inst_n_1161 VSS=VSS VDD=VDD
Xg10873__6131 NOR2X1 $PINS Z=n_109 A=n_44 B=soc_can_rx_inst_n_1158 VSS=VSS
+ VDD=VDD
Xg10874__1881 NAND2X1 $PINS Z=n_217 A=n_97 B=n_72 VSS=VSS VDD=VDD
Xg10875 INVX2 $PINS Z=n_106 A=n_107 VSS=VSS VDD=VDD
Xg10876 INVX2 $PINS Z=n_104 A=n_105 VSS=VSS VDD=VDD
Xg10883 INVX2 $PINS Z=n_11 A=n_13 VSS=VSS VDD=VDD
Xg10884__5115 AND2X1 $PINS Z=n_102 A=n_20 B=soc_uart_tx_inst_shift_reg[9]
+ VSS=VSS VDD=VDD
Xg10886__7482 NAND2X1 $PINS Z=n_101 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[7] VSS=VSS VDD=VDD
Xg10887__4733 NAND2X1 $PINS Z=n_100 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[8] VSS=VSS VDD=VDD
Xg10888__6161 OR2X1 $PINS Z=n_99 A=soc_uart_tx_inst_Status_reg[1]
+ B=soc_uart_tx_inst_Status_reg[2] VSS=VSS VDD=VDD
Xg10889__9315 OR2X1 $PINS Z=n_98 A=n_30 B=soc_uart_rx_inst_bit_count[2] VSS=VSS
+ VDD=VDD
Xg10890__9945 NAND2X1 $PINS Z=n_97 A=n_840 B=n_23 VSS=VSS VDD=VDD
Xg10891__2883 NAND2X1 $PINS Z=n_96 A=n_21 B=soc_uart_tx_data_Bus[6] VSS=VSS
+ VDD=VDD
Xg10892__2346 NAND2X1 $PINS Z=n_95 A=n_21 B=soc_uart_tx_data_Bus[7] VSS=VSS
+ VDD=VDD
Xg10893__1666 NAND2X1 $PINS Z=n_94 A=n_21 B=soc_uart_tx_data_Bus[5] VSS=VSS
+ VDD=VDD
Xg10894__7410 NAND2X1 $PINS Z=n_93 A=n_21 B=soc_uart_tx_data_Bus[4] VSS=VSS
+ VDD=VDD
Xg10895__6417 NAND2X1 $PINS Z=n_92 A=n_21 B=soc_uart_tx_data_Bus[3] VSS=VSS
+ VDD=VDD
Xg10896__5477 NAND2X1 $PINS Z=n_91 A=n_21 B=soc_uart_tx_data_Bus[1] VSS=VSS
+ VDD=VDD
Xg10897__2398 NAND2X1 $PINS Z=n_90 A=n_21 B=soc_Load_XMT_datareg VSS=VSS
+ VDD=VDD
Xg10898__5107 NAND2X1 $PINS Z=n_89 A=n_21 B=soc_uart_tx_data_Bus[2] VSS=VSS
+ VDD=VDD
Xg10899__6260 NAND2X1 $PINS Z=n_88 A=n_21 B=soc_uart_tx_data_Bus[0] VSS=VSS
+ VDD=VDD
Xg10900__4319 OR2X1 $PINS Z=n_87 A=n_8 B=n_828 VSS=VSS VDD=VDD
Xg10901__8428 OR2X1 $PINS Z=n_86 A=n_7 B=n_829 VSS=VSS VDD=VDD
Xg10903__5526 NAND2X1 $PINS Z=n_85 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[8] VSS=VSS VDD=VDD
Xg10904__6783 NAND2X1 $PINS Z=n_84 A=n_840 B=soc_can_data_ready VSS=VSS VDD=VDD
Xg10905__3680 NAND2X1 $PINS Z=n_83 A=soc_uart_rx_inst_state[0] B=n_23 VSS=VSS
+ VDD=VDD
Xg10906__1617 NAND2X1 $PINS Z=n_82 A=n_5 B=soc_can_tx_inst_shift_reg[106]
+ VSS=VSS VDD=VDD
Xg10907__2802 NAND2X1 $PINS Z=n_81 A=n_5 B=soc_can_tx_inst_shift_reg[103]
+ VSS=VSS VDD=VDD
Xg10908__1705 NAND2X1 $PINS Z=n_80 A=n_5 B=soc_can_tx_inst_shift_reg[104]
+ VSS=VSS VDD=VDD
Xg10909__5122 NAND2X1 $PINS Z=n_79 A=n_5 B=soc_can_tx_inst_shift_reg[105]
+ VSS=VSS VDD=VDD
Xg10910__8246 NAND2X1 $PINS Z=n_78 A=n_5 B=soc_can_tx_inst_shift_reg[99]
+ VSS=VSS VDD=VDD
Xg10911__7098 NAND2X1 $PINS Z=n_77 A=n_5 B=soc_can_tx_inst_shift_reg[102]
+ VSS=VSS VDD=VDD
Xg10912__6131 NAND2X1 $PINS Z=n_76 A=n_5 B=soc_can_tx_inst_shift_reg[10]
+ VSS=VSS VDD=VDD
Xg10914__1881 NOR2X1 $PINS Z=n_75 A=n_24 B=n_845 VSS=VSS VDD=VDD
Xg10915__5115 NAND2X1 $PINS Z=n_108 A=soc_uart_rx_inst_state[1] B=n_23 VSS=VSS
+ VDD=VDD
Xg10917__7482 NAND2X1 $PINS Z=n_107 A=soc_uart_rx_inst_state[1] B=n_22 VSS=VSS
+ VDD=VDD
Xg10918__4733 NOR2X1 $PINS Z=n_105 A=soc_uart_tx_inst_state[0] B=n_20 VSS=VSS
+ VDD=VDD
Xg10919__6161 NOR2X1 $PINS Z=n_13 A=soc_can_tx_inst_state[0] B=n_5 VSS=VSS
+ VDD=VDD
Xg10920 INVX2 $PINS Z=n_74 A=n_73 VSS=VSS VDD=VDD
Xg10921 INVX2 $PINS Z=n_70 A=n_69 VSS=VSS VDD=VDD
Xg10922 INVX2 $PINS Z=n_66 A=n_65 VSS=VSS VDD=VDD
Xg10923__9315 NOR2X1 $PINS Z=n_63 A=soc_uart_tx_inst_Status_reg[1]
+ B=soc_uart_tx_inst_Status_reg[0] VSS=VSS VDD=VDD
Xg10924__9945 AND2X1 $PINS Z=n_62 A=soc_uart_data_ready
+ B=soc_Load_frame_datareg VSS=VSS VDD=VDD
Xg10925__2883 NAND2X1 $PINS Z=n_61 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[2] VSS=VSS VDD=VDD
Xg10926__2346 OR2X1 $PINS Z=n_60 A=soc_can_tx_inst_status_reg[0]
+ B=soc_can_tx_inst_state[0] VSS=VSS VDD=VDD
Xg10927__1666 NAND2X1 $PINS Z=n_59 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[4] VSS=VSS VDD=VDD
Xg10928__7410 NAND2X1 $PINS Z=n_58 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[7] VSS=VSS VDD=VDD
Xg10929__6417 NAND2X1 $PINS Z=n_57 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[6] VSS=VSS VDD=VDD
Xg10930__5477 NAND2X1 $PINS Z=n_56 A=soc_can_tx_inst_shift_reg[6]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10931__2398 NAND2X1 $PINS Z=n_55 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[1] VSS=VSS VDD=VDD
Xg10932__5107 NAND2X1 $PINS Z=n_54 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[3] VSS=VSS VDD=VDD
Xg10933__6260 NAND2X1 $PINS Z=n_53 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[5] VSS=VSS VDD=VDD
Xg10934__4319 NAND2X1 $PINS Z=n_52 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[3] VSS=VSS VDD=VDD
Xg10935__8428 NAND2X1 $PINS Z=n_51 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[6] VSS=VSS VDD=VDD
Xg10936__5526 NAND2X1 $PINS Z=n_50 A=soc_can_tx_inst_shift_reg[3]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10937__6783 NAND2X1 $PINS Z=n_49 A=soc_can_tx_inst_shift_reg[7]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10938__3680 NAND2X1 $PINS Z=n_48 A=n_30 B=n_22 VSS=VSS VDD=VDD
Xg10939__1617 NAND2X1 $PINS Z=n_47 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[9] VSS=VSS VDD=VDD
Xg10940__2802 NAND2X1 $PINS Z=n_46 A=soc_can_tx_inst_shift_reg[9]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10941__1705 OR2X1 $PINS Z=n_45 A=soc_can_tx_inst_status_reg[1]
+ B=soc_can_tx_inst_status_reg[2] VSS=VSS VDD=VDD
Xg10942__5122 NAND2X1 $PINS Z=n_44 A=soc_can_rx_inst_bit_count[4]
+ B=soc_can_rx_inst_bit_count[5] VSS=VSS VDD=VDD
Xg10943__8246 NAND2X1 $PINS Z=n_43 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[2] VSS=VSS VDD=VDD
Xg10944__7098 NOR2X1 $PINS Z=n_42 A=soc_can_tx_inst_status_reg[4]
+ B=soc_can_tx_inst_state[0] VSS=VSS VDD=VDD
Xg10945__6131 NAND2X1 $PINS Z=n_41 A=soc_uart_tx_inst_state[0]
+ B=soc_uart_tx_inst_shift_reg[5] VSS=VSS VDD=VDD
Xg10946__1881 NAND2X1 $PINS Z=n_40 A=soc_uart_tx_inst_state[1]
+ B=soc_uart_tx_inst_shift_reg[4] VSS=VSS VDD=VDD
Xg10947__5115 NOR2X1 $PINS Z=n_39 A=n_27 B=n_23 VSS=VSS VDD=VDD
Xg10948__7482 NAND2X1 $PINS Z=n_38 A=soc_can_tx_inst_shift_reg[1]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10949__4733 NOR2X1 $PINS Z=n_37 A=soc_can_index[0] B=soc_uart_data_ready
+ VSS=VSS VDD=VDD
Xg10950__6161 NAND2X1 $PINS Z=n_36 A=soc_can_tx_inst_shift_reg[8]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10951__9315 NAND2X1 $PINS Z=n_35 A=soc_can_tx_inst_shift_reg[10]
+ B=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg10952__9945 NAND2X1 $PINS Z=n_73 A=soc_Load_frame_datareg B=soc_Can_ID_Bus[0]
+ VSS=VSS VDD=VDD
Xg10953__2883 NAND2X1 $PINS Z=n_72 A=soc_can_rx_inst_state[1]
+ B=soc_can_rx_inst_state[2] VSS=VSS VDD=VDD
Xg10954__2346 NAND2X1 $PINS Z=n_71 A=soc_can_tx_inst_status_reg[5]
+ B=soc_can_tx_inst_status_reg[4] VSS=VSS VDD=VDD
Xg10955__1666 AND2X1 $PINS Z=n_69 A=soc_uart_rx_inst_bit_count[0] B=rbyte_PAD
+ VSS=VSS VDD=VDD
Xg10956__7410 AND2X1 $PINS Z=n_68 A=soc_can_index[0] B=soc_uart_data_ready
+ VSS=VSS VDD=VDD
Xg10957__6417 NAND2X1 $PINS Z=n_67 A=n_830 B=soc_uart_tx_inst_n_126 VSS=VSS
+ VDD=VDD
Xg10958__5477 AND2X1 $PINS Z=n_65 A=soc_can_tx_inst_status_reg[0]
+ B=soc_can_tx_inst_status_reg[1] VSS=VSS VDD=VDD
Xg10959__2398 AND2X1 $PINS Z=n_64 A=soc_uart_tx_inst_Status_reg[0]
+ B=soc_uart_tx_inst_Status_reg[1] VSS=VSS VDD=VDD
Xg10960 INVX2 $PINS Z=n_34 A=soc_uart_rx_inst_bit_count[3] VSS=VSS VDD=VDD
Xg10976 INVX2 $PINS Z=n_31 A=soc_can_rx_inst_bit_count[3] VSS=VSS VDD=VDD
Xg10978 INVX2 $PINS Z=n_30 A=soc_uart_rx_inst_state[1] VSS=VSS VDD=VDD
Xg10983 INVX2 $PINS Z=n_8 A=soc_uart_tx_inst_state[0] VSS=VSS VDD=VDD
Xg10990 INVX2 $PINS Z=n_7 A=soc_can_tx_inst_state[0] VSS=VSS VDD=VDD
Xg11006 INVX8 $PINS Z=n_5 A=soc_can_tx_inst_state[1] VSS=VSS VDD=VDD
Xg11032 INVX2 $PINS Z=n_27 A=ser_rx_PAD VSS=VSS VDD=VDD
Xg11042 INVX2 $PINS Z=n_24 A=soc_can_rx_inst_bit_count[2] VSS=VSS VDD=VDD
Xg11046 INVX2 $PINS Z=n_23 A=rbyte_PAD VSS=VSS VDD=VDD
Xg11047 INVX2 $PINS Z=n_22 A=soc_uart_rx_inst_state[0] VSS=VSS VDD=VDD
Xg11050 INVX2 $PINS Z=n_20 A=soc_uart_tx_inst_state[1] VSS=VSS VDD=VDD
Xg11069 INVX1 $PINS Z=soc_can_rx_inst_n_1142 A=soc_can_rx_inst_state[2] VSS=VSS
+ VDD=VDD
Xg2 NAND2X1 $PINS Z=n_840 A=soc_can_rx_inst_n_1142 B=n_32 VSS=VSS VDD=VDD
Xg4 INVX1 $PINS Z=n_844 A=n_843 VSS=VSS VDD=VDD
Xg11072 MUX2X1 $PINS Z=n_843 A=n_842 B=n_577 S=soc_uart_rx_inst_bit_count[2]
+ VSS=VSS VDD=VDD
Xg3 OR2X1 $PINS Z=n_842 A=n_107 B=n_326 VSS=VSS VDD=VDD
Xg11073 NAND2X1 $PINS Z=n_845 A=soc_can_rx_inst_bit_count[0]
+ B=soc_can_rx_inst_bit_count[1] VSS=VSS VDD=VDD
Xg11075 MUX2X1 $PINS Z=n_848 A=n_847 B=n_744 S=soc_can_tx_inst_status_reg[5]
+ VSS=VSS VDD=VDD
Xg11076 AND2X1 $PINS Z=n_847 A=n_365 B=soc_can_tx_inst_status_reg[4] VSS=VSS
+ VDD=VDD
Xg11077 MUX2X1 $PINS Z=n_850 A=n_849 B=n_387 S=soc_can_tx_inst_status_reg[3]
+ VSS=VSS VDD=VDD
Xg11078 AND2X1 $PINS Z=n_849 A=n_13 B=n_323 VSS=VSS VDD=VDD
Xg11079 MUX2X1 $PINS Z=n_852 A=n_851 B=n_338 S=soc_uart_rx_inst_bit_count[1]
+ VSS=VSS VDD=VDD
Xg11080 NOR2X1 $PINS Z=n_851 A=n_70 B=n_107 VSS=VSS VDD=VDD
Xg11081 MUX2X1 $PINS Z=n_854 A=n_853 B=n_294 S=soc_can_tx_inst_status_reg[1]
+ VSS=VSS VDD=VDD
Xg11082 AND2X1 $PINS Z=n_853 A=soc_can_tx_inst_status_reg[0] B=n_13 VSS=VSS
+ VDD=VDD
.ENDS
.GLOBAL VDD
.GLOBAL VSS
